# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${BPN}.inc
SRCREV = "bd111966bace6886869bb6e9bf5a688d9cdc31bc"
