# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${BPN}.inc
SRC_URI = "https://download.kde.org/stable/kweathercore/${PV}/${BPN}-${PV}.tar.xz"
SRC_URI[sha256sum] = "9bcac13daf98705e2f0d5b06b21a1a8694962078fce1bf620dbbc364873a0efe"
