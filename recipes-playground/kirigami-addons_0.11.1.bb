# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${BPN}.inc
#FIXME this is an inofficial hash that contains CMake compile fixes for 0.11.1
SRCREV = "028ebd8c285b01abf93f32edb134f4221b0e2ce5"
