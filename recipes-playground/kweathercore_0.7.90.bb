# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${BPN}.inc
#TODO this is an arbitrary hash from master branch that supports Qt6
SRCREV = "d8d0fb8f5b1e59e8c965f6c10c43ffc23b156a50"
