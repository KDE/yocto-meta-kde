# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${BPN}.inc
SRCREV = "b6ef51c830b85a080e09ca205bae667890601df1"
