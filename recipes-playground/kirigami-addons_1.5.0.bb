# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${BPN}.inc
SRCREV = "b713db2a32ff0847f48a066eeeae61f641fbe3e1"
