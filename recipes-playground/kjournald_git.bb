# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${BPN}.inc
SRCREV = "16e5da2b98cc1123b244ada185e3075dc74417ec"
