# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${BPN}.inc
SRCREV = "48271a4fa38f4d515fa43df2eb7620ab849b3715"
