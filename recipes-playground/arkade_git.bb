# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${BPN}.inc
SRCREV = "7cc24608cfd91630745efbb2003ac4af5f7b01d6"
