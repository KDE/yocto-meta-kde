# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${BPN}.inc
SRCREV = "81ee895cd9947a691c27f981f3aae39d4c6f51ad"
