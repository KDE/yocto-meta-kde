# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${BPN}.inc
SRCREV = "384037ece90bd62574d04d30b9f31bf12426bdb6"
