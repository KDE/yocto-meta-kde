# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${BPN}.inc
# v0.6.0
SRCREV = "887bf3a093c2d5d59ac31bf3ef6e360874a985c1"
