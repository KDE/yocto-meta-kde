require ${BPN}.inc
# SRCREV = "v${PV}"
SRCREV = "3666d1bd1bd9d7fe77d78d9e87d898342014a62b"
