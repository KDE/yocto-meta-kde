# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${BPN}.inc
SRCREV = "6be6cda2aa181fdbe35181701cb79ec5e0797266"
