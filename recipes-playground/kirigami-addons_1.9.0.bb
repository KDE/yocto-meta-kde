# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${BPN}.inc
SRCREV = "d53b2b24608ae66dbaa4f09d8d7ebae6c9f642b5"
