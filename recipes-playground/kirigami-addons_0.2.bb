# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${BPN}.inc
SRCREV = "72e9a61e4b55f2558b8bfaeca8b533cf6275a4f5"
