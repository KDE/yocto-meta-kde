require ${BPN}.inc
# SRCREV = "v${PV}"
SRCREV = "7ce39d54ba99c0357f46df1be7b49b6c4c8be4b2"
