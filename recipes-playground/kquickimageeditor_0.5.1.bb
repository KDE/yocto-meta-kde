# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${BPN}.inc
SRCREV = "673816f603550a9e7e62c5dadf077926d5de6857"
