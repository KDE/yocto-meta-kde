# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

# arbitrary git version
PV = "5.27.80"
require ${BPN}.inc
SRCREV = "7e09c4f8db9b2821297f974ecd499eb1ad9ce058"
