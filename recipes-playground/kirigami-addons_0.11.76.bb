# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${BPN}.inc
SRCREV = "8cc87f2c9c15fa7eb698701b0723f3d62c5ec894"
