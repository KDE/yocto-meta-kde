# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${BPN}.inc
SRCREV = "01d8aa9811b5e9e1fd8a9e91f8ef269f3518a030"
