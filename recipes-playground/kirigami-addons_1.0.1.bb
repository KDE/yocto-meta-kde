# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${BPN}.inc
SRCREV = "a1a67ea76b9ea88aed176a52b3eb53d383cb420b"
