# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${BPN}.inc
SRCREV = "97aaacfd259f95b60b3897143e1939f5631ad1bc"
