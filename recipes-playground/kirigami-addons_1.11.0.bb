# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${BPN}.inc
# v1.11.0
SRCREV = "10ad7ec72702b6eddaab037e379f0df6aaddd310"
