# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${BPN}.inc
SRCREV = "ab68812b70703fdc357eb05d2cce43669d74f7cb"
