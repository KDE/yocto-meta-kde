# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${BPN}.inc
# v1.12.0
SRCREV = "d544a188ac2cac376a3595e3d440586c69a458d9"
