# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${BPN}.inc
SRCREV = "dff2292184d31d004965f3067e9386f069654bce"
