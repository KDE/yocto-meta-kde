# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${BPN}.inc
SRCREV = "f5139864e47e0ec328ba3a8cee1da53a616eb618"
