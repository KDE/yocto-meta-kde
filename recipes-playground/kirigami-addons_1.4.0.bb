# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${BPN}.inc
SRCREV = "1cd7a1cf5c96e365aa01c08544ff7784fd3c8d2d"
