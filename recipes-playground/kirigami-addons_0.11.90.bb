# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${BPN}.inc
SRCREV = "33e69e62fa19ec51fdd889298b74f8846dd98d33"
