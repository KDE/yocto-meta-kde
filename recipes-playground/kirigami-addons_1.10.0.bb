# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${BPN}.inc
# v1.10.0
SRCREV = "aa5b65fa50d7b88a5a828b562cf770b3dcc4db7f"
