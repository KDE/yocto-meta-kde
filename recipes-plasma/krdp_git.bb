# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

PV = "6.1.3"
require ${BPN}.inc
SRCREV = "2d95ca34ac465936f274a54e733a93589cef14d7"
