# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.6.5/layer-shell-qt-6.6.5.tar.xz"
SRC_URI[sha256sum] = "e8c145545ac49d5325f16ff710b521deab6e5b9745fcc18ab431252224a8f982"

