# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/5.27.4/kscreenlocker-5.27.4.tar.xz"
SRC_URI[sha256sum] = "a9da7f59b3fe35879adae4c67d1b2263085ee5c79004cd2bec46ce6901b97191"

