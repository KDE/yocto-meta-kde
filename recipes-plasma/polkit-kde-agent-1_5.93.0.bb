# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.93.0/polkit-kde-agent-1-5.93.0.tar.xz"
SRC_URI[sha256sum] = "abb57495965a26eeb6342b4c4943b54f3159dc1031356909703488f4ff374a7f"

