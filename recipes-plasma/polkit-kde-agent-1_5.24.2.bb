# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.24.2/polkit-kde-agent-1-5.24.2.tar.xz"
SRC_URI[sha256sum] = "43685eccd228edf74c7fee80f6cafb217159b540b487cda067c18e3ec6b7ba7d"

