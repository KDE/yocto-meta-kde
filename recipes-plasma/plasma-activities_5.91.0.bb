# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.91.0/plasma-activities-5.91.0.tar.xz"
SRC_URI[sha256sum] = "ec0958ef2002a6a2236b7402c2d1b952ce00770514f3eccc575d3e7f941884bd"

