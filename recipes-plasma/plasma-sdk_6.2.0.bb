# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.0/plasma-sdk-6.2.0.tar.xz"
SRC_URI[sha256sum] = "d8a1b0022d16035f71393aa35e816bc1e2d6dc3bb1ad769483d4589e8b78c216"

