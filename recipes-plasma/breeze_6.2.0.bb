# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.0/breeze-6.2.0.tar.xz"
SRC_URI[sha256sum] = "f965a09fe199846d55366c6114ea933673ca4cc7dcb81e240c9c0ae47915ee51"

