# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.2/plasma-systemmonitor-6.2.2.tar.xz"
SRC_URI[sha256sum] = "204cd673b9164497b9b6b5292d8b4d6874180e8815e72419ed5af76693e3d345"

