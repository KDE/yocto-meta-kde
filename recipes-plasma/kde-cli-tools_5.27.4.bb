# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/5.27.4/kde-cli-tools-5.27.4.tar.xz"
SRC_URI[sha256sum] = "c594fde05df078eb9d0455b0e298c201a3143b949c1c3b1ff5526b5e4340b419"

