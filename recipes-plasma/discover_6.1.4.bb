# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.1.4/discover-6.1.4.tar.xz"
SRC_URI[sha256sum] = "64e73e990bebe13a2614245f03beb51c5027c285fc793309a2cff79e6156d284"

