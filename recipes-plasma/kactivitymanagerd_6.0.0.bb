# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.0.0/kactivitymanagerd-6.0.0.tar.xz"
SRC_URI[sha256sum] = "9210b391c329018e45ac65c6e3a77f64532f3e0176c589bcd76460c2030102fc"

