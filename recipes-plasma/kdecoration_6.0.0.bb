# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.0.0/kdecoration-6.0.0.tar.xz"
SRC_URI[sha256sum] = "363a5d23d90952a5e2e32bc7fbf41ff4dbbb7ccff138bef19d48b3dad11f1551"

