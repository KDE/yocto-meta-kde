# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.1.3/plasma-disks-6.1.3.tar.xz"
SRC_URI[sha256sum] = "116edeb311b2887c47fda7eb2040e0238cec30990ae928f96e2b35c78c7ff3c6"

