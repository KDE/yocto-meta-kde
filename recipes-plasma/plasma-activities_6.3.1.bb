# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.1/plasma-activities-6.3.1.tar.xz"
SRC_URI[sha256sum] = "6e1e4f23f9e8b3f8deea9304df1179ea30b0ab6a11cb9f4d7ca21b15e5791a6e"

