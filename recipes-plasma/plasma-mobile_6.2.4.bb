# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.4/plasma-mobile-6.2.4.tar.xz"
SRC_URI[sha256sum] = "ed198ecc902bdcec3d66bf1e3d60421450ec3f5dea74b1395aa6a27d1eeea0af"

