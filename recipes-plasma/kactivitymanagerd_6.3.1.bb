# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.1/kactivitymanagerd-6.3.1.tar.xz"
SRC_URI[sha256sum] = "b435fb044f66648b7c976979cbb8de1567fce3a511e84d61276d1637119cdea4"

