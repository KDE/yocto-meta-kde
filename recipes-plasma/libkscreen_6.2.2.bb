# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.2/libkscreen-6.2.2.tar.xz"
SRC_URI[sha256sum] = "361e8af0d0c5a48f9e4a238216c32834f9424db420421fde42fd7e38135651ad"

