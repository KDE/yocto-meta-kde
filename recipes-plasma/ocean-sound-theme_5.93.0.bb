# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.93.0/ocean-sound-theme-5.93.0.tar.xz"
SRC_URI[sha256sum] = "0a380b4e6e91a1b5a5deeed0c67adeda2b59f25bc2c7711217be628226a00f78"

