# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.1.3/bluedevil-6.1.3.tar.xz"
SRC_URI[sha256sum] = "b9a2880d361a1967bd8de9e50887ccd63b5e9ca9bb935e1948f6b619a2682b39"

