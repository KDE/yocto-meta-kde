# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.90.0/plasma-systemmonitor-5.90.0.tar.xz"
SRC_URI[sha256sum] = "557aad1fae01ad9038637a07c20e228af052754115e13578b3d510901e7862d3"

