# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.24.5/plasma-pa-5.24.5.tar.xz"
SRC_URI[sha256sum] = "068f0d393a87d3f3c8031eaecd1c2d2bdb17e73c510e020280ab18da3c15f8d1"

