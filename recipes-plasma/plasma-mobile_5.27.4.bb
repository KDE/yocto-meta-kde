# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/5.27.4/plasma-mobile-5.27.4.tar.xz"
SRC_URI[sha256sum] = "d518075aa3f895617816b5f2415d4fc280c55ba35973ed92fe3fda6ea1a505a8"

