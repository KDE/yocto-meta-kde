# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.4/discover-6.2.4.tar.xz"
SRC_URI[sha256sum] = "619a8a80670f52d00bbe67daea22d1db0d7c9b44b57865dc972558061bad1427"

