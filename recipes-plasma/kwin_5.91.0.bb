# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.91.0/kwin-5.91.0.tar.xz"
SRC_URI[sha256sum] = "1e9bc0e7ea4e87d9d64888dcb80ee0ed5ca37ad2c071f1ae4a2ae3ddf4e29144"

