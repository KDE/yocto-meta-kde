# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.6.5/plasma-nm-6.6.5.tar.xz"
SRC_URI[sha256sum] = "c92d09d2978dbbe6b5c897beac822cd053c17473f1d61506e152bfcb46b70b9b"

