# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.26.0/plasma-bigscreen-5.26.0.tar.xz"
SRC_URI[sha256sum] = "39b1d60d83505c603d9b31374f2b5748c2d0e32310980242d0eead0b8c13bbca"

