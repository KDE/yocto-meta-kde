# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.26.0/plasma-integration-5.26.0.tar.xz"
SRC_URI[sha256sum] = "af61b043d696799acd6991b59f590c9e36c7ea3aa08b1993c0e356ab144c1b57"

