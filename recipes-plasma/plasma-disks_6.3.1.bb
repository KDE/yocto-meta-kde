# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.1/plasma-disks-6.3.1.tar.xz"
SRC_URI[sha256sum] = "eae814c033e83733f0925b0cbd8a400d7f30a2524e97b2032669596b35e66cbe"

