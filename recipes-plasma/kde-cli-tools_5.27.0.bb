# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.27.0/kde-cli-tools-5.27.0.tar.xz"
SRC_URI[sha256sum] = "15113efa066d1d04516828f5a187f3a03bc348c890714900e5655bc7fbeaacf0"

