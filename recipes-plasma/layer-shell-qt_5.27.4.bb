# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/5.27.4/layer-shell-qt-5.27.4.tar.xz"
SRC_URI[sha256sum] = "3b3aedc14b23023c8e8a4e5d0a16711f24b505cd8a2f470baf595a6ed0e3d0fe"

