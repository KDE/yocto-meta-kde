# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.22.5/discover-5.22.5.tar.xz"
SRC_URI[sha256sum] = "c9809ec8f3f26909ce9901d6f7cd03cf52d4854431cfdf5340a4daa8404842b0"

