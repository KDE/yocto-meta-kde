# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.5.2/plasma5support-6.5.2.tar.xz"
SRC_URI[sha256sum] = "811551c98c4bf042b791e2635a900fe76aaf2b0dc71b54dec80f9c387f74b8ef"

