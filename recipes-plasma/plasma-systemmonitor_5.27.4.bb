# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/5.27.4/plasma-systemmonitor-5.27.4.tar.xz"
SRC_URI[sha256sum] = "294847847d9ade0cad8723f4af95bf5b36588c43c69ae4e624aaee3c2b45c3eb"

