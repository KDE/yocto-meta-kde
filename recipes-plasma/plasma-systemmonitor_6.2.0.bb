# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.0/plasma-systemmonitor-6.2.0.tar.xz"
SRC_URI[sha256sum] = "95983dc41a7f25f7c0bfe81852c7b808f217d6d8bebb5d140bd4205859685a17"

