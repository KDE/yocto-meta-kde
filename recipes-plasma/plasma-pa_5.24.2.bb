# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.24.2/plasma-pa-5.24.2.tar.xz"
SRC_URI[sha256sum] = "015dff4f7561a0fdca28a0d49e98df3bb112300c9e29588f685e58ae037603e6"

