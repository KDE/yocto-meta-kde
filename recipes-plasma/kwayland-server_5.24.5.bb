# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.24.5/kwayland-server-5.24.5.tar.xz"
SRC_URI[sha256sum] = "2ddabe29794489d11096ed831ad4d5c1626130019322d4305d58df84c835b279"

