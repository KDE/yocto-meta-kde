# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/5.27.4/kscreen-5.27.4.tar.xz"
SRC_URI[sha256sum] = "456f249772f53807dcc0b5076dcf6975d5b29b0b2b6a037ca0a5e45017a4c5ed"

