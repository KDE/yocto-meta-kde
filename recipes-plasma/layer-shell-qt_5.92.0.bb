# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.92.0/layer-shell-qt-5.92.0.tar.xz"
SRC_URI[sha256sum] = "66fddd39189cca1ea0b13188f976e0cd606079ca9cf81089d276ec316c305af2"

