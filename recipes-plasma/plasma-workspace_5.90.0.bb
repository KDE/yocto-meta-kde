# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.90.0/plasma-workspace-5.90.0.tar.xz"
SRC_URI[sha256sum] = "e3987220a0f4c635532687cc463368009320f3c96adac82725640296bc86d61a"

