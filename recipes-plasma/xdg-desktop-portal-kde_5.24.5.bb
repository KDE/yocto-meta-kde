# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.24.5/xdg-desktop-portal-kde-5.24.5.tar.xz"
SRC_URI[sha256sum] = "b59ccf65d29aef2ce6af9757a5c87eddd87b633fba2e45470f92b18b2ce5c6fe"

