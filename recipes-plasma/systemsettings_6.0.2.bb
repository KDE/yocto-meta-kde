# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.0.2/systemsettings-6.0.2.tar.xz"
SRC_URI[sha256sum] = "de5950beef63444984fa61e3874c6013a4ffeebfce6d819cf7bab7c82402b606"

