# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.1.4/xdg-desktop-portal-kde-6.1.4.tar.xz"
SRC_URI[sha256sum] = "38ca15fd86d5fef2cc79ac98f56b4cd3d93cefd32e82d3b2246bb77402dca7b2"

