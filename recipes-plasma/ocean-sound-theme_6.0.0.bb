# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.0.0/ocean-sound-theme-6.0.0.tar.xz"
SRC_URI[sha256sum] = "22a0edca869c79b49be5a255b6c3dfb0d2584c9ef68dbb7906138a7c96f679fa"

