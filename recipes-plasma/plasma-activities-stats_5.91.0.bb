# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.91.0/plasma-activities-stats-5.91.0.tar.xz"
SRC_URI[sha256sum] = "364b18ac0eef048b18d7cb1cc738bd4c91f462004f731e369ee09c2246bde36e"

