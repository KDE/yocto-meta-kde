# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.1.4/milou-6.1.4.tar.xz"
SRC_URI[sha256sum] = "72803ccc20a7846ee4598fe1eb2c85a1bcfe68ac5e23766e4b4b607a52720082"

