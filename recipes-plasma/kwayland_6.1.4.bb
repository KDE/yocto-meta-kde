# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.1.4/kwayland-6.1.4.tar.xz"
SRC_URI[sha256sum] = "8691c06e65ac2c739de4842c0d1219579efb4ae1864b8614dc74a4645dd59774"

