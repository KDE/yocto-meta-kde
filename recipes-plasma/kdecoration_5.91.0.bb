# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.91.0/kdecoration-5.91.0.tar.xz"
SRC_URI[sha256sum] = "caa958a28d32501bfb4303969851c9dbeaa3774b780e735becf9df35980ccd32"

