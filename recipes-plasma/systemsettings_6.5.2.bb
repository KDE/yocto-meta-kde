# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.5.2/systemsettings-6.5.2.tar.xz"
SRC_URI[sha256sum] = "f6f3b2192160f08c829c00fe4c0315f9c06288d4c4daf287141e11e83d8a4bce"

