# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.22.5/plasma-phone-components-5.22.5.tar.xz"
SRC_URI[sha256sum] = "40669f5218ac04d7e1aa71ffecf2376a6de5e747da1d24adee37cbe6e7e35ad4"

