# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.5.2/aurorae-6.5.2.tar.xz"
SRC_URI[sha256sum] = "f38d5855cffa9d7a29fa803934bba7c8a6847243ef773b55f223e864b79d98d3"

