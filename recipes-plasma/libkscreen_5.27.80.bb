# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.27.80/libkscreen-5.27.80.tar.xz"
SRC_URI[sha256sum] = "fcd6a4d5417edce81722a8c3462d9f14957d1c97a5d4b535b0d8d0ffcec2b3ae"

