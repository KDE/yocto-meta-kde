# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.26.0/plasma-mobile-5.26.0.tar.xz"
SRC_URI[sha256sum] = "c21f62d1c2f76034370e7e8ed87b0c71f28f898c4c7df045340b6387debd877f"

