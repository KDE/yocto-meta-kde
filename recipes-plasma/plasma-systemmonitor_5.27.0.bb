# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.27.0/plasma-systemmonitor-5.27.0.tar.xz"
SRC_URI[sha256sum] = "5d5fd3a9268d095b38a6f73c88b8a4e33509f4f43a6796dd3dac4fcf37f6328d"

