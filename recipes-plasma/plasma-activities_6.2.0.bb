# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.0/plasma-activities-6.2.0.tar.xz"
SRC_URI[sha256sum] = "2ace92ac64b2ea318b050345d514a03ac0f90fa26586882c1d9b4166fe00f2d7"

