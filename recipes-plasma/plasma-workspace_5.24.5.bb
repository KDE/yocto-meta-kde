# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.24.5/plasma-workspace-5.24.5.tar.xz"
SRC_URI[sha256sum] = "b9912691e0becfa0839dbf7750ea24729b72bad0216bef27584f9faf882064f6"

