# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.27.0/plasma-nano-5.27.0.tar.xz"
SRC_URI[sha256sum] = "41f7c926014cba57ae2fe94404e60fb4b95b16df2d8c1b5f50c372be56738869"

