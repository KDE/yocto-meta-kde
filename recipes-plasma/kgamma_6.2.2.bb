# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.2/kgamma-6.2.2.tar.xz"
SRC_URI[sha256sum] = "34522988ba7445e6bf1aa7aead419ff54b6e1afccd34ac8a9519416ab6a10dce"

