# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "git://invent.kde.org/plasma/kpipewire.git;nobranch=1;protocol=https"
SRCREV = "5cca7b26db2822b818f1f6083f0846b9f579fc44"
S = "${WORKDIR}/git"
