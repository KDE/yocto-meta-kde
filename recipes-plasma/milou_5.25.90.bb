# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "git://anongit.kde.org/milou;nobranch=1;protocol=https"
SRCREV = "1c2904e54db9b6ef3699a98544bbdb6fd01ee377"
S = "${WORKDIR}/git"
