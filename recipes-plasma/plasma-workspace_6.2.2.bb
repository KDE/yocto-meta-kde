# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.2/plasma-workspace-6.2.2.tar.xz"
SRC_URI[sha256sum] = "becc89473d57dcc574a8d9d626cc83b446df2567a478a663f81d58fd6ea3f853"

