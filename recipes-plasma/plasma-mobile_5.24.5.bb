# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.24.5/plasma-mobile-5.24.5.tar.xz"
SRC_URI[sha256sum] = "ed2b3f08ddb5ed91e33651f3707a3379274721eb5b3803bc9be4af4b3acf0010"

