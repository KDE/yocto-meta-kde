# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.25.1/kwayland-integration-5.25.1.tar.xz"
SRC_URI[sha256sum] = "412c470210593e0d3624370edf8d17f5a58145bafd3b7a2e8f5377e48ecc00e5"

