# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.27.80/polkit-kde-agent-1-5.27.80.tar.xz"
SRC_URI[sha256sum] = "e29092abfc15bc026ff0be30609ec017482f9296f4b4ba5b65ded6f7f496f69d"

