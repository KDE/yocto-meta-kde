# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.22.5/libksysguard-5.22.5.tar.xz"
SRC_URI[sha256sum] = "a522ab976baafa8c1b80cbfe6a4d7718aa8c8623f84294d25c5d43429dd472c2"

