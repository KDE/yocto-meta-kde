# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.1.3/krdp-6.1.3.tar.xz"
SRC_URI[sha256sum] = "9797b9fa9ce76f48c72d93272bdd47c778e760d4a6d94c1f63922275b346d3ea"
