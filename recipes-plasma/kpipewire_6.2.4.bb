# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.4/kpipewire-6.2.4.tar.xz"
SRC_URI[sha256sum] = "76e456206a9f6e922cb10614476a19682f8c27957c5c8998f1d1a0dadb94ca6b"

