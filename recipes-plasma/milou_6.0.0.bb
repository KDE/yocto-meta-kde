# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.0.0/milou-6.0.0.tar.xz"
SRC_URI[sha256sum] = "c8ea924f7c3915e1deaa5220ba007238526b3df9029b3ac98eca158e5552b34a"

