# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "git://anongit.kde.org/kscreenlocker;nobranch=1;protocol=https"
SRCREV = "762dfdcb72340c5ea676aaa17857ec91b4218b62"
S = "${WORKDIR}/git"
