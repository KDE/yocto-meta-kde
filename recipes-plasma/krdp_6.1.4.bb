# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.1.4/krdp-6.1.4.tar.xz"
SRC_URI[sha256sum] = "74de8e185be67d35bdd66a4194c79d7fe4d98794a33ec9be915433c86bc591cb"

