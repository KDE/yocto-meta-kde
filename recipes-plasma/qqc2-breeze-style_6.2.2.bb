# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.2/qqc2-breeze-style-6.2.2.tar.xz"
SRC_URI[sha256sum] = "ee35872c964a15ea48481fd48220006e425ecf855a91c2baa4dbf8b23f8a43cb"

