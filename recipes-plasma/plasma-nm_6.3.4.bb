# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.4/plasma-nm-6.3.4.tar.xz"
SRC_URI[sha256sum] = "fdcae645be226927225aaca71b4fda11a43adca169982b69c9ad8016c69da0bd"

