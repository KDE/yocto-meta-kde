# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.4/plasma-sdk-6.3.4.tar.xz"
SRC_URI[sha256sum] = "aea52ef5905552d5242e8974d2f9e053445764650bc263bb0f35ee43a5cb09cc"

