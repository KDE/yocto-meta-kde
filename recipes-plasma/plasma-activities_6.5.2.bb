# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.5.2/plasma-activities-6.5.2.tar.xz"
SRC_URI[sha256sum] = "39783d324f3c03404521b49264d34135756d00bcead46177a4b989f8bea7449a"

