# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.26.0/aura-browser-5.26.0.tar.xz"
SRC_URI[sha256sum] = "a9de5d2ff23d30ce0c13509bd6af6aa63c863a4db3fdb1cc5650ea2ae5b983e4"

