# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.93.0/discover-5.93.0.tar.xz"
SRC_URI[sha256sum] = "b9029066e928219a2c9d87bd0db112897bb3fe0171bae0f8e38c77de04121799"

