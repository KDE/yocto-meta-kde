# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.92.0/plasma-activities-stats-5.92.0.tar.xz"
SRC_URI[sha256sum] = "c66c65815891436edb5b1dbfd566c1e5dd3ee4f408a7a89569f4ca9279c07a12"

