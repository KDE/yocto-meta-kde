# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.22.5/kscreenlocker-5.22.5.tar.xz"
SRC_URI[sha256sum] = "28edcf841db79554ac113c8619d20f978b2ab81bfd5d5be25f973506f262f180"

