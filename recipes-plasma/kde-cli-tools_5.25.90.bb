# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "git://anongit.kde.org/kde-cli-tools;nobranch=1;protocol=https"
SRCREV = "fcdaee5f81eab68bdb923ed3faf9ae25a2165f4f"
S = "${WORKDIR}/git"
