# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.93.0/libplasma-5.93.0.tar.xz"
SRC_URI[sha256sum] = "a6042fc71870ba064487e49c44b7a04ade3f5add0b60302b27c72d79120d72bc"

