# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.92.0/kactivitymanagerd-5.92.0.tar.xz"
SRC_URI[sha256sum] = "469c27e060826a470a50d3d71bb466ad125a5c4a9856d73832392a46df304d1f"

