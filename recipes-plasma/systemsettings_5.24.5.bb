# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.24.5/systemsettings-5.24.5.tar.xz"
SRC_URI[sha256sum] = "5b72b53f0bd8760b35844732a60f99713d45d0f80cecaca80de965e84effe9e5"

