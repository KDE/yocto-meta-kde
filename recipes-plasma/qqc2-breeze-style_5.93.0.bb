# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.93.0/qqc2-breeze-style-5.93.0.tar.xz"
SRC_URI[sha256sum] = "dbef905d6dc735af8249524de5f20c20cdaf7fb6db0d3c3467eb47240913d5c6"

