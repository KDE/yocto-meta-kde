require ${PN}.inc
#SRCREV = "v${PV}"
SRCREV= "63a541c4425fddea8d08d82e0be90e7a99b6bc8a"
