# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.93.0/systemsettings-5.93.0.tar.xz"
SRC_URI[sha256sum] = "8e0d704994914c9b969f0d906781d2bdfbb67cf07ac250e698823848b14a6b06"

