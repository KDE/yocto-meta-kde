# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.90.0/layer-shell-qt-5.90.0.tar.xz"
SRC_URI[sha256sum] = "ccda2aa681bdeb3128cb03e80954b8b36dcdb6eb53b0cd99928f721dd32c00df"

