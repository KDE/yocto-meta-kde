# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.26.4/systemsettings-5.26.4.tar.xz"
SRC_URI[sha256sum] = "15d84cc969636e9e9dc3b9c36a5b1c6c881067184077ba9bbdc5a080719e80f2"

