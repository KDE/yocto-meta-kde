# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.0/polkit-kde-agent-1-6.2.0.tar.xz"
SRC_URI[sha256sum] = "c6650c57de4e1d59cc5148edb2b8d7f17a66c20785613ec30535174a7b6dcb10"

