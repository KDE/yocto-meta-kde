# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.4/polkit-kde-agent-1-6.2.4.tar.xz"
SRC_URI[sha256sum] = "12de45e157239b581f21bdd9a3eda3ff73bc55300ba979a42c9799f1b7753f8d"

