# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.91.0/kscreen-5.91.0.tar.xz"
SRC_URI[sha256sum] = "f5c1061f3085a7262a9efd8e06966c72dce1accbbe69519ffc4b0068f67313ac"

