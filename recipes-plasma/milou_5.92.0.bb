# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.92.0/milou-5.92.0.tar.xz"
SRC_URI[sha256sum] = "91a6af4612b7031de7e839ab5e3697105d575ea00e7b83e2c7c43aba43a58d41"

