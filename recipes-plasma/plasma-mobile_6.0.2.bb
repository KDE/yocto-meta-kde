# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.0.2/plasma-mobile-6.0.2.tar.xz"
SRC_URI[sha256sum] = "2d080cab40af60e6ca3eb03c13a5f0b6dad1102c6c0941193a64f24c37957f72"

