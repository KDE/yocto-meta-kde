# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.1/ksystemstats-6.3.1.tar.xz"
SRC_URI[sha256sum] = "b084ab61b2b73b51d2250bdcfebe6cbcbf3fd0f6a5b7141ad211a141a66a4edb"

