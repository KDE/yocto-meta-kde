# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.24.5/libksysguard-5.24.5.tar.xz"
SRC_URI[sha256sum] = "b06cb33a6e17c04c47ed4ded72a122acd6a2af60776c18719cdd74be27eb41ec"

