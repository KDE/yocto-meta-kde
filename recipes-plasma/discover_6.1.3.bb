# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.1.3/discover-6.1.3.tar.xz"
SRC_URI[sha256sum] = "45a297dfcb9070aabc8dda0bbe78da9a300b27073b31756e8a4e81a5f9885183"

