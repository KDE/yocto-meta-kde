# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.90.0/systemsettings-5.90.0.tar.xz"
SRC_URI[sha256sum] = "66ebe0aa02ce794f6d642f0d4554a996f76f08ff619a99d1098d2289d0398519"

