# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.5.2/polkit-kde-agent-1-6.5.2.tar.xz"
SRC_URI[sha256sum] = "351ccd623fee873c1d7a70f40e0a05bf984ead14791cd9257b2b7bdd2ddc04cc"

