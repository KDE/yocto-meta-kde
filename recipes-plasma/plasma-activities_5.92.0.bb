# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.92.0/plasma-activities-5.92.0.tar.xz"
SRC_URI[sha256sum] = "2ac1e844f8e840a8b77e3323c4badcf8ed5997633d6cc12812d157bb50fe77c3"

