# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.27.80/qqc2-breeze-style-5.27.80.tar.xz"
SRC_URI[sha256sum] = "9dbd730d7585cb8cbfa3eab0db3fbbdb4e42b4b34cd71b902dd3f4e0dbad0f9d"
