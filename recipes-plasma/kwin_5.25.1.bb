# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.25.1/kwin-5.25.1.tar.xz"
SRC_URI[sha256sum] = "1d39953c907c71411eb870ce2039501abb84ce202e8c226b6372227e436f3ceb"

