# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.4/plasma-systemmonitor-6.2.4.tar.xz"
SRC_URI[sha256sum] = "4796b5a571ff4396fd4755b1b090b27c23fa596b8715c32ce4a0315d12c8064c"

