# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.0.0/kscreenlocker-6.0.0.tar.xz"
SRC_URI[sha256sum] = "2502faa85c87460a4b5eabb92769d33c196cd3373b3f3a521ed396e504d22ab6"

