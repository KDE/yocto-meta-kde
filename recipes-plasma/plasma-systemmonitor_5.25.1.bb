# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.25.1/plasma-systemmonitor-5.25.1.tar.xz"
SRC_URI[sha256sum] = "be9bca58fdc53eabf52d87eb6f7b347b3922f1314513b12b10d99489ad2cd5d0"

