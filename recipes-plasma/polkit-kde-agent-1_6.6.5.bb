# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.6.5/polkit-kde-agent-1-6.6.5.tar.xz"
SRC_URI[sha256sum] = "91990b9cd13f205a9963f88fe605942b9e8b6ee9e9103431216bf511944ce127"

