# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.25.1/powerdevil-5.25.1.tar.xz"
SRC_URI[sha256sum] = "c41ecd197a8def2a7b4231e5d8a642c8b858c940d529d22a1b3bd273caada754"

