# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.91.0/kglobalacceld-5.91.0.tar.xz"
SRC_URI[sha256sum] = "59c033b1cc72e84ec71bf3bc3f85122cf4a24c118e0881fff3bf5419fe98c249"

