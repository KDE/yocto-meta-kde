# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.1.4/plasma-workspace-6.1.4.tar.xz"
SRC_URI[sha256sum] = "cb2099dd39c0b23ff4b05c8cf657845187075d31f75fe41f0fe01edce56c8d56"

