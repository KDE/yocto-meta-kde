# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.24.5/kscreen-5.24.5.tar.xz"
SRC_URI[sha256sum] = "d9c351ad25783596aae466e305ad80de48ff3094a219ec6ffe08c7870ea3b5bc"

