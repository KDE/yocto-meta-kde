# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.0.2/qqc2-breeze-style-6.0.2.tar.xz"
SRC_URI[sha256sum] = "904e6398aee2ad31291c027ab096a197c942eb4a73eef7f4de4282cbca6b325d"

