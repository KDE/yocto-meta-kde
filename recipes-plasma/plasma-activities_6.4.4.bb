# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.4.4/plasma-activities-6.4.4.tar.xz"
SRC_URI[sha256sum] = "ab810aa594ed3386f6a8564705ea2a46cc62ec367de2039625e030f6af955fe8"

