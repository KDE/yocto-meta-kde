# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.92.0/libkscreen-5.92.0.tar.xz"
SRC_URI[sha256sum] = "a9d5e76b8cfac7d622204b0c3f06670313ed13d156d3f85d5a27defec0cad43c"

