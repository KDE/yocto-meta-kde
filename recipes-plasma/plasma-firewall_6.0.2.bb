# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.0.2/plasma-firewall-6.0.2.tar.xz"
SRC_URI[sha256sum] = "20ee33e804ec75df7137d6b473cf5d46a779ab6645dd09494f67f7d10ed4a928"

