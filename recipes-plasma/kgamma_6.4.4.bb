# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.4.4/kgamma-6.4.4.tar.xz"
SRC_URI[sha256sum] = "1bc752415d4711580f483f774a62d8959583686b93b164484a89d7d5571334a6"

