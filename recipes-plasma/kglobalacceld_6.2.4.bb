# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.4/kglobalacceld-6.2.4.tar.xz"
SRC_URI[sha256sum] = "d22904e2c8342dbccf7a8197d260cc0df7f5eca5ae659ab81315573db80d367a"

