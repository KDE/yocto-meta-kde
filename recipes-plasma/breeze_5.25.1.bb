# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.25.1/breeze-5.25.1.tar.xz"
SRC_URI[sha256sum] = "502b88efa1c220639d940bd1e397ee83d82c041e2367e5ece978b8dad6ee1c8f"

