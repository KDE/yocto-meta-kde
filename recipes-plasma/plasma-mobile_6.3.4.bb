# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.4/plasma-mobile-6.3.4.tar.xz"
SRC_URI[sha256sum] = "ba1edce064529adca747f01209b876e8c441cef46ffaad70de8bbf631f3d5559"

