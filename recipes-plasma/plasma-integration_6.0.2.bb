# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.0.2/plasma-integration-6.0.2.tar.xz"
SRC_URI[sha256sum] = "26a7db6b0eb7548b400ebfacb4d53fe1bbbc3c0c7b3e0ebf76e5552bcc02a0fc"

