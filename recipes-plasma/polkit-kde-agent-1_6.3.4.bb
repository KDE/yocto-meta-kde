# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.4/polkit-kde-agent-1-6.3.4.tar.xz"
SRC_URI[sha256sum] = "a797f6e02491a2fc60eda14a75e5e796b56513303c99b7465fd964227e98c4cf"

