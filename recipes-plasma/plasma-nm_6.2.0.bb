# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.0/plasma-nm-6.2.0.tar.xz"
SRC_URI[sha256sum] = "ce72008abf17555d1b20f66480ff21992a7c44b26cf056a133fd2d2ee7421e75"

