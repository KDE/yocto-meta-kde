# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.22.5/layer-shell-qt-5.22.5.tar.xz"
SRC_URI[sha256sum] = "ffcc705ae4fadabc3422b8331a8d6334e2ce197ca6fadd7343c0a48927d32f45"

