# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.4/plasma-activities-stats-6.2.4.tar.xz"
SRC_URI[sha256sum] = "c2271850b57b0da6e84e61049c3dd6d60244e47482245672a9c220debf04ccbb"

