# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.93.0/xdg-desktop-portal-kde-5.93.0.tar.xz"
SRC_URI[sha256sum] = "a3c721c626b562fa96ee1a65b5079020b4f376fae9629f260f047254792e43e1"

