# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.93.0/plasma-pa-5.93.0.tar.xz"
SRC_URI[sha256sum] = "1a4b2d1bd3f396ebc00db24a927303b70d4927e56dc0554f367d002d97768e9d"

