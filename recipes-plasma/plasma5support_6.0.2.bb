# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.0.2/plasma5support-6.0.2.tar.xz"
SRC_URI[sha256sum] = "18b1de3461f5f3721c5d3cbb084113a0ceea5bf3e376f21b24fe98ca56d54a6f"

