# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.26.4/libksysguard-5.26.4.tar.xz"
SRC_URI[sha256sum] = "eb954bab3eb26e4b891e0838097529fe73499b2f843bc1ed17ccc64db085b5e8"

