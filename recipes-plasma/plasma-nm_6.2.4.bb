# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.4/plasma-nm-6.2.4.tar.xz"
SRC_URI[sha256sum] = "f4363f327ccd757fb013dd4bf2992a37a58db6b6627cf2d010f30d5afafd832a"

