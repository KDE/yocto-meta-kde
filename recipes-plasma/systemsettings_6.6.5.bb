# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.6.5/systemsettings-6.6.5.tar.xz"
SRC_URI[sha256sum] = "61334eff64567ad209e279f60c6d1ab13b670f9a300fde9480fe93596232a986"

