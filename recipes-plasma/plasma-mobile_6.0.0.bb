# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.0.0/plasma-mobile-6.0.0.tar.xz"
SRC_URI[sha256sum] = "d76f07e1147fd2eb6a32e35d7cb4c84795eda32b161cb0a60a04676a1e9a6ff3"

