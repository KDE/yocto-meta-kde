# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.93.0/kscreenlocker-5.93.0.tar.xz"
SRC_URI[sha256sum] = "be0e9ada6c617a40d45e40d1095c26aaac758fd5f1b239df4896e5b64af05b76"

