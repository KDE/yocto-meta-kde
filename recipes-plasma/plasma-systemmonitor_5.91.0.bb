# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.91.0/plasma-systemmonitor-5.91.0.tar.xz"
SRC_URI[sha256sum] = "aaa3f7f746561e779e7d87702150921e1f6207cd5359febf29affb50cbae074c"

