# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.0/libkscreen-6.2.0.tar.xz"
SRC_URI[sha256sum] = "b601873845b0504690d21248591c1ad2a99bbce35dbeac747c575cc321c4d485"

