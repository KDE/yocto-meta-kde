# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.0.0/kde-cli-tools-6.0.0.tar.xz"
SRC_URI[sha256sum] = "4370c93bb5c205ef32bf48bc00f263eaa390b7f1b46df875a42fcbffbf428741"

