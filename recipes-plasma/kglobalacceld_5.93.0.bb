# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.93.0/kglobalacceld-5.93.0.tar.xz"
SRC_URI[sha256sum] = "4e20380ca4a818daabc81889684ad5bf6c3c201e7a206b670f2514d1cc25a53b"

