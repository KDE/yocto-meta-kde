# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.0/plasma-mobile-6.2.0.tar.xz"
SRC_URI[sha256sum] = "f593d864450bfb1079605c1723b282e4015cfb77a0eb3376488c770f04b79d48"

