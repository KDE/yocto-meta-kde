# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.92.0/breeze-5.92.0.tar.xz"
SRC_URI[sha256sum] = "031426b9ad28352c7688487f8ee2a54b4c3cc59478602de7e745bff98ec3cf82"

