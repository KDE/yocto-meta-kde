# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.26.0/plasma-nm-5.26.0.tar.xz"
SRC_URI[sha256sum] = "7e9adf6bbbd565227871f80716b46d86deddad32628b150185d38a1d70245eae"

