# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.5.2/kdecoration-6.5.2.tar.xz"
SRC_URI[sha256sum] = "2963dc44ff2b1cc7ea44cbb3800d35c4d0bcead783728179afda504cc0611576"

