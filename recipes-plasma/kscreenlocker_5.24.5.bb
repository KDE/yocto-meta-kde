# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.24.5/kscreenlocker-5.24.5.tar.xz"
SRC_URI[sha256sum] = "3270a1845c9fc694a50db38de4c27586d2f488152e1bcf88be0088d6799bf98e"

