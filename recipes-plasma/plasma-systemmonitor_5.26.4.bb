# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.26.4/plasma-systemmonitor-5.26.4.tar.xz"
SRC_URI[sha256sum] = "c9511d9d820785a382d615ababeb4689136e6defb78e80b951da1915c3b059c1"

