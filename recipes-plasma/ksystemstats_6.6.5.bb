# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.6.5/ksystemstats-6.6.5.tar.xz"
SRC_URI[sha256sum] = "6b5e2f2a6aaae97489e75818e7f83c2586578022760821c677cdebcefa542e36"

