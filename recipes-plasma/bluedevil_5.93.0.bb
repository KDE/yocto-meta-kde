# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.93.0/bluedevil-5.93.0.tar.xz"
SRC_URI[sha256sum] = "690ea863af230320978a257448b1615742e5738e222cfb721180f61f413549db"

