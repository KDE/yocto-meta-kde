# Fix for missing runtime dependency in libcanberra
RDEPENDS:libcanberra-pulseaudio = "libcanberra"
RDEPENDS:libcanberra-alsa = "libcanberra"
