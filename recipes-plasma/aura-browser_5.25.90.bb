# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "git://anongit.kde.org/aura-browser;nobranch=1;protocol=https"
SRCREV = "c5db2e5190fa87c59851fcf443a6c0d04ff1e08f"
S = "${WORKDIR}/git"
