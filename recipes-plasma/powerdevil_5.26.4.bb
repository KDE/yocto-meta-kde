# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.26.4/powerdevil-5.26.4.tar.xz"
SRC_URI[sha256sum] = "a39f83175603eca8e966eb6d7fb33528afe3d6a877d0ffbe5016471c76b755e9"

