# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.0.0/plasma-welcome-6.0.0.tar.xz"
SRC_URI[sha256sum] = "c6285518c2c72107c6827a9d7198f93a1f30aec6f99993c2a311e3137fd3e66c"

