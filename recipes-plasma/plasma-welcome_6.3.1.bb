# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.1/plasma-welcome-6.3.1.tar.xz"
SRC_URI[sha256sum] = "40db580f769265710d198d76f90df87dac5ecd0f1cfb8470c99c8c3f1fd62b1b"

