# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.24.2/plasma-integration-5.24.2.tar.xz"
SRC_URI[sha256sum] = "b6408b32e13b9713cd34f499c7aae216218a04b6c9655f37689d95f8b323f947"

