# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.1/kglobalacceld-6.3.1.tar.xz"
SRC_URI[sha256sum] = "ddccbb289cabd689fab2b5aecb143e920f97c3a444f80f3f9c40db99bd46718a"

