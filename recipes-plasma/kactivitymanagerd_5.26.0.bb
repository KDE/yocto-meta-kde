# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.26.0/kactivitymanagerd-5.26.0.tar.xz"
SRC_URI[sha256sum] = "d2621bb7ecaa13348d8790d432a1dd4bebd145730550d0fa2e8fcb2818b30dd1"

