# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.0.0/plasma-disks-6.0.0.tar.xz"
SRC_URI[sha256sum] = "b82ffe327db6edd746c422f71e0071523713de6d9b2f46fb0e12d03002874f2a"

