# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.0/plasma-activities-stats-6.2.0.tar.xz"
SRC_URI[sha256sum] = "215d7728537b890a1f319f13caa6038c02dc4e3e64d99cf40ce08fc82f465dfd"

