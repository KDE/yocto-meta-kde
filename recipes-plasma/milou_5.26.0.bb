# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.26.0/milou-5.26.0.tar.xz"
SRC_URI[sha256sum] = "c0efe738142ade01d6b9730502cee6ab70827e26be403e7a639fc84f7d508fbc"

