require ${PN}.inc
SRCREV = "e4f4d768c1603799add19d1471927b9131cefe1e"
