# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.25.1/plasma-workspace-5.25.1.tar.xz"
SRC_URI[sha256sum] = "1368df30e17edb7f58418e9822b21e68748d4251d66d069c4aa383af474f36de"

