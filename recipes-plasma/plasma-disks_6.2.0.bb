# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.0/plasma-disks-6.2.0.tar.xz"
SRC_URI[sha256sum] = "581fba7b97397853442e9203e02cc5fe6007a1f6d6020bd3383751d7a70d2ba1"

