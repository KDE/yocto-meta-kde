# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.0.2/plasma-disks-6.0.2.tar.xz"
SRC_URI[sha256sum] = "3d67869bbe46a82b983b1f6dc08626d0d361740446c7000575d735456522f0b6"

