# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.92.0/plasma-disks-5.92.0.tar.xz"
SRC_URI[sha256sum] = "30dab1946c0ba9326a7ea9c9c41c77b1f7d752a3b44e9f10ecc5c9584808573d"

