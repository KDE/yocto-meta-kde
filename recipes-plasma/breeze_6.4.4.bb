# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.4.4/breeze-6.4.4.tar.xz"
SRC_URI[sha256sum] = "307cfcb5505bd376d959b364f5231cac4a280af938a938ce3a4e3b7a9f71f70d"

