# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.6.5/libksysguard-6.6.5.tar.xz"
SRC_URI[sha256sum] = "f088854a021028b7b0f6a735c89e9aa53bd13e903af11ed16a49c944e33b00df"

