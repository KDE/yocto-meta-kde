# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.1.4/kpipewire-6.1.4.tar.xz"
SRC_URI[sha256sum] = "ab116d56fd8a6b36da6b595f597cf4383d8ed171f8e625dca67b7a4645337134"

