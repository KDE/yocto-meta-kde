# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.22.5/plasma-integration-5.22.5.tar.xz"
SRC_URI[sha256sum] = "28c743f1a911042dac1dd86ae615748b7b5422e8d4b47bff34d31cf4bdb6f270"

