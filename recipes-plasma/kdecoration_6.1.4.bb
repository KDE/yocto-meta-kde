# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.1.4/kdecoration-6.1.4.tar.xz"
SRC_URI[sha256sum] = "87f0e00869078e104855192ab42db63d1d6a4d2ba5e90bf3536908b5e4b7bbf1"

