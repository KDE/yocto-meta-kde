# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.25.1/plasma-integration-5.25.1.tar.xz"
SRC_URI[sha256sum] = "f2b132b0374e21eb5c49c4871336d85f1c5ed3fcf36b8bf4960b8959ae5cb727"

