# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.27.0/libksysguard-5.27.0.tar.xz"
SRC_URI[sha256sum] = "652d37197c05c43d3033c67153d482a238cac97351054d4c82e67e3745719a06"

