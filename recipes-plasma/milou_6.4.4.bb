# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.4.4/milou-6.4.4.tar.xz"
SRC_URI[sha256sum] = "a644e5965b33c20f82ce51660fa3b7c2d41810b068cf21f77658824cb3ea6b1e"

