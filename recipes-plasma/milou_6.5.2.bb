# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.5.2/milou-6.5.2.tar.xz"
SRC_URI[sha256sum] = "84b379c41a154ea24c0223c46cb7f91ea5410f27a3cff012b4aedc3841e79bbd"

