# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.0.2/powerdevil-6.0.2.tar.xz"
SRC_URI[sha256sum] = "3188d3c8cadddf68955efc96e9e4e1292eb3d167e4da59029adc993e2151f548"

