# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.4/kscreenlocker-6.2.4.tar.xz"
SRC_URI[sha256sum] = "129d10c3892222168dbbf80cdbda810ad062c26de51f7cbc2590e655f553cb16"

