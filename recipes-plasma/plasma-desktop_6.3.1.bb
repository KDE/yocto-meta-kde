# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.1/plasma-desktop-6.3.1.tar.xz"
SRC_URI[sha256sum] = "119c9d361274367048320864cbaffc612530cba4ea62d6dfd504f3efe5b254a4"

