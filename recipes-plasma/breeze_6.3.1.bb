# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.1/breeze-6.3.1.tar.xz"
SRC_URI[sha256sum] = "2c73f5593c97661fc25fb1af7aa029cdbbf9374cb842b036b553c0bcc499951c"

