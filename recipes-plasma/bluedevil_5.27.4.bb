# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/5.27.4/bluedevil-5.27.4.tar.xz"
SRC_URI[sha256sum] = "101871f56da19ae667d61ec32addc446eb94f81ce0c541cf0367de96c3c896a3"

