# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.25.1/discover-5.25.1.tar.xz"
SRC_URI[sha256sum] = "3a716ef8273a456fa1d38d7a17b64303204c89ec5356858bdcf9d2ee3089f5b2"

