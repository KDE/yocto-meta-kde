# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.26.4/plasma-pa-5.26.4.tar.xz"
SRC_URI[sha256sum] = "6ac43cf4fb3f60a18cbd33749a87efd2123d9ff0954e677918d50468d95b1940"

