# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.91.0/qqc2-breeze-style-5.91.0.tar.xz"
SRC_URI[sha256sum] = "ee8b21b91458c859f054b24cca1e82ea67fabda36987a5614d198698628dbc16"

