# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.24.2/bluedevil-5.24.2.tar.xz"
SRC_URI[sha256sum] = "24d7501e65149093e17c8545199d1bcae27fe828ded65d6a20446c8fffe1fa2a"

