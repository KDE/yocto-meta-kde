# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.0.2/kscreenlocker-6.0.2.tar.xz"
SRC_URI[sha256sum] = "451c69a2356c545c118e32c9f8b4586272b299f8d9ddc4c9c884b19db427b53f"

