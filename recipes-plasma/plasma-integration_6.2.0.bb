# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.0/plasma-integration-6.2.0.tar.xz"
SRC_URI[sha256sum] = "dcd10a0c8418524e66c6ea7bfba4de4d4f20469db470b41a50ae20e359e9b768"

