# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.0/kglobalacceld-6.2.0.tar.xz"
SRC_URI[sha256sum] = "2157492575c0d829fc91624c071a4d2b811fac9ccc6430f149c1dd07866e4d7c"

