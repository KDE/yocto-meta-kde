# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.27.0/bluedevil-5.27.0.tar.xz"
SRC_URI[sha256sum] = "9e521661fc0c7212e91a3ea56c99ff5c52d46a18f7d02d6a47b3d5858ca15472"

