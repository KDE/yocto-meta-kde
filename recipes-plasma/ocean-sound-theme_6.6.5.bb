# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.6.5/ocean-sound-theme-6.6.5.tar.xz"
SRC_URI[sha256sum] = "46b76160e6998e03b3990c669d6da166bd785da356841193eb548b35811dc6df"

