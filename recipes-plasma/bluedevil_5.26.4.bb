# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.26.4/bluedevil-5.26.4.tar.xz"
SRC_URI[sha256sum] = "be1e6d34e1e19f7402ef79bd66aced3c72893f3e769ee7bbee51e5af3bb506a1"

