# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.5.2/krdp-6.5.2.tar.xz"
SRC_URI[sha256sum] = "20ab2722f229710669200c3dfc35888cec6e2b3c38dce120bb05b99ca37d58ff"

