# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/5.27.4/plasma-workspace-5.27.4.1.tar.xz"
SRC_URI[sha256sum] = "cb3906ac954bfd0784614843b1aaf9abda640ea3ed944d8651aaa4149baf65a5"

