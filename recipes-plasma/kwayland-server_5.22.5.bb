# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.22.5/kwayland-server-5.22.5.tar.xz"
SRC_URI[sha256sum] = "dd64bdd629b239621d687d8deceff6e0da88542c6b67140c5ff8b654155bf39d"

