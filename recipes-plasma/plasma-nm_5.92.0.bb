# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.92.0/plasma-nm-5.92.0.tar.xz"
SRC_URI[sha256sum] = "8399b2ec9d59b105e650ff15a85d0fd3c71414c0bb839d582fcee7e105dbaae4"

