# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.6.5/plasma-keyboard-6.6.5.tar.xz"
SRC_URI[sha256sum] = "3bb8be109cc449af54d03f28cc1c1a9e4d4150cb01b9af916a5516ed64740671"

