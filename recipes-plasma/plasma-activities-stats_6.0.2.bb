# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.0.2/plasma-activities-stats-6.0.2.tar.xz"
SRC_URI[sha256sum] = "d7e492d07c957b5ea6c4530b1f19d38a2abdec66bca5346e08e7efc9ae15906c"

