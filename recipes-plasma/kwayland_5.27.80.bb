# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.27.80/kwayland-5.27.80.tar.xz"
SRC_URI[sha256sum] = "9c236a4767d5e727f68eaf144d38c3f84e26ea2d61adfbf4b2868ba9b623b846"

