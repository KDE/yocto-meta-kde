# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.0.0/plasma-desktop-6.0.0.tar.xz"
SRC_URI[sha256sum] = "924ce04db2c88cf7ae1a23f19b38eb452977087b6e937ed0568ce5397bcc927d"

