# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.6.5/plasma-welcome-6.6.5.tar.xz"
SRC_URI[sha256sum] = "bc9427d739cdc8ba7f49fe62d02a716351a772df1b2b696c6c1f08695c4126a2"

