# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.6.5/plasma-disks-6.6.5.tar.xz"
SRC_URI[sha256sum] = "660609a1f489c197d35419aeacbc08ec724c5e13538a736eb3d81ac331b9f639"

