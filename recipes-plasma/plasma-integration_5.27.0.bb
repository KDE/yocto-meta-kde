# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.27.0/plasma-integration-5.27.0.tar.xz"
SRC_URI[sha256sum] = "3cb091a677bfbfacbdffdd1a2c0e76afded539db3a48b2d5358236face8b4655"

