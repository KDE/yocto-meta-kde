# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.25.1/libksysguard-5.25.1.tar.xz"
SRC_URI[sha256sum] = "c6fa1dc61132ac41d15501328f86f62de73b3d845bc264d831fdbd041929c4f6"

