# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.92.0/plasma-integration-5.92.0.tar.xz"
SRC_URI[sha256sum] = "dbce852c746d2e2443ddaccc3066959fb206923e4d6b61caf4a50950c6853453"

