# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.90.0/libksysguard-5.90.0.tar.xz"
SRC_URI[sha256sum] = "c12c0f854d808a14b93e8b025ceb610e1146116fb44628ec4dc4d49fb400d47c"

