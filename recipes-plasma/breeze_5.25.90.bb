# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "git://anongit.kde.org/breeze;nobranch=1;protocol=https"
SRCREV = "a29a736fa60aeb91abc13fc282c73678e07eb735"
S = "${WORKDIR}/git"
