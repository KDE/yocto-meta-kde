# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/5.27.4/powerdevil-5.27.4.tar.xz"
SRC_URI[sha256sum] = "a70e673638dfdd4157332b262bf101eae0cc1ac73ffb22225bd6012483a3153e"

