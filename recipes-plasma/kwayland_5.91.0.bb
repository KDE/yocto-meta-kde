# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.91.0/kwayland-5.91.0.tar.xz"
SRC_URI[sha256sum] = "6e7d22eaf10eaf6587d2fb63b60bf88db3c018a98f364187a08634d695dae9d8"

