# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.91.0/kpipewire-5.91.0.tar.xz"
SRC_URI[sha256sum] = "9c86b4d411898ffb4b23de519868adb00d3cd3b2764524c53d04d961e1a8c968"

