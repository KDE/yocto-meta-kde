# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.27.0/plasma-remotecontrollers-5.27.0.tar.xz"
SRC_URI[sha256sum] = "242c4d5bcd22da523b38412e9d1467c9417472199e974a8b24f3a4884b961c61"

