# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.2/plasma-disks-6.2.2.tar.xz"
SRC_URI[sha256sum] = "a0101b10dd6f4bbbdd479a0ce8ae60c2fb9a98cc882ca1e1c59b534c661a17e9"

