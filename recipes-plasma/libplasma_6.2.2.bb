# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.2/libplasma-6.2.2.tar.xz"
SRC_URI[sha256sum] = "df43da9f3d745ceece1bcfc2c6746107553bb9f37bf0ec0ad10253418c7e6048"

