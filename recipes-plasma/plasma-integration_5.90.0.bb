# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.90.0/plasma-integration-5.90.0.tar.xz"
SRC_URI[sha256sum] = "fd5258a40703c7481505fb6864ac74272061d52b24183ee779176f87a3eac855"

