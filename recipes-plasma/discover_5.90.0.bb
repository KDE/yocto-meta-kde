# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.90.0/discover-5.90.0.tar.xz"
SRC_URI[sha256sum] = "0faaab1a765e2a2ab04ee3a48fceac23822f61e382d59ceed54689767f7b019f"

