# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.0/qqc2-breeze-style-6.2.0.tar.xz"
SRC_URI[sha256sum] = "1197fb335656cc85a99294e95a2f01f43688eddf5458da92a144e7b6182b5498"

