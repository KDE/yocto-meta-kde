# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.4/plasma-desktop-6.3.4.tar.xz"
SRC_URI[sha256sum] = "db24c3c5d4c3e0c1214b51ad688ab603c2c9eb4eb82d973bdaaad67519a2c57f"

