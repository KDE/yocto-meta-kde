# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.2/plasma-firewall-6.2.2.tar.xz"
SRC_URI[sha256sum] = "d2c948bdffcdf981d0d354e3f598f15dbead1846c7c0b4cbfe7aab1f41d0b2d5"

