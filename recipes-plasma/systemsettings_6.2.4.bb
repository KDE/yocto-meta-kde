# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.4/systemsettings-6.2.4.tar.xz"
SRC_URI[sha256sum] = "6179f33c358f9b966e6fb79a7ed62717aa8e74975956e75ab0fa78725087c156"

