# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/5.27.4/milou-5.27.4.tar.xz"
SRC_URI[sha256sum] = "4d0f67b80f0580dbd4479dfa65e597fed2b8f9ab671eca3d7f5156f6871f57a8"

