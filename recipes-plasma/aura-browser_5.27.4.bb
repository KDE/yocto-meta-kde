# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/5.27.4/aura-browser-5.27.4.tar.xz"
SRC_URI[sha256sum] = "89912b04016d5d198d9cafc305511287345dc29be4a28857bc7c9265efb8c954"

