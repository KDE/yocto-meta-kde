# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.26.0/plasma-nano-5.26.0.tar.xz"
SRC_URI[sha256sum] = "e71bfbf7990e29084d88ab1894dce5eedad10dff3f45f862080777de910fcb32"

