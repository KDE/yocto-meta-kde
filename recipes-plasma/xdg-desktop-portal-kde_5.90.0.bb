# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.90.0/xdg-desktop-portal-kde-5.90.0.tar.xz"
SRC_URI[sha256sum] = "c6cad48a78b50e403b4323bcedefef7d239ac82b46d8b2bd99943f236b1e9fdc"

