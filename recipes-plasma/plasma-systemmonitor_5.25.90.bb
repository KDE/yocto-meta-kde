# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "git://anongit.kde.org/plasma-systemmonitor;nobranch=1;protocol=https"
SRCREV = "1969110d83bb164b956c0495447b939bc4590bf0"
S = "${WORKDIR}/git"
