# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.4/plasma-welcome-6.2.4.tar.xz"
SRC_URI[sha256sum] = "d909c479f97479964232fda1f80b053a54c3a748e5127c211b93870762e6b653"

