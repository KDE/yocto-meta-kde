# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.1/krdp-6.3.1.tar.xz"
SRC_URI[sha256sum] = "0c20ccf0ea57fd9e27d4288cbc05f406f4f64d0de6490d4dad57ab177aa98db1"

