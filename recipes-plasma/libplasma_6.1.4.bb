# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.1.4/libplasma-6.1.4.tar.xz"
SRC_URI[sha256sum] = "2afe314d9960e86e0d1799aac26904c5665be2934d5d9d5c8533ba962a6b8410"

