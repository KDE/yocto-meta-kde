# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.1/libksysguard-6.3.1.tar.xz"
SRC_URI[sha256sum] = "c223e5290562b52a910c70260b3ca27334728e6a635911eb6726a872e7178ba6"

