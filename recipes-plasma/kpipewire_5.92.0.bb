# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.92.0/kpipewire-5.92.0.tar.xz"
SRC_URI[sha256sum] = "89537ab244584e76dda97857a548b5f6d143383a496c5c4068a0c18b5930483f"

