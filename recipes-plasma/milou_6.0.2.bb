# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.0.2/milou-6.0.2.tar.xz"
SRC_URI[sha256sum] = "58a3db1eff597cb203959ea30aa49688e2f428adad388c54e2cbae810af41a14"

