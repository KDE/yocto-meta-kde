# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.5.2/plasma-vault-6.5.2.tar.xz"
SRC_URI[sha256sum] = "c055f858687eb6f6226d38cf8455bdf55106e9efa6bdb3d7b03b90a9ffa6ce69"

