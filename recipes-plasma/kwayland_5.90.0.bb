# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.90.0/kwayland-5.90.0.tar.xz"
SRC_URI[sha256sum] = "1a749c4515f17f33e3a7609fa24caf8d20945c6406250745d7c632b4dffc9ab7"

