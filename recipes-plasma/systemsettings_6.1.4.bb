# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.1.4/systemsettings-6.1.4.tar.xz"
SRC_URI[sha256sum] = "c0ea266277ccb759a7b3b9c589d6099674f3e3f603e7aa471ed89dc6ad007da3"

