# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.1/plasma-integration-6.3.1.tar.xz"
SRC_URI[sha256sum] = "446567571dc8b43447b7b7afd7b82d9ba2a60421393c85cbb109bb65f540a9c2"

