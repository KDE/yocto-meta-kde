# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.4/libplasma-6.3.4.tar.xz"
SRC_URI[sha256sum] = "880b970b9221fb39278f4ea928145b0ae4db368c2739b5dac9a69dfcd000f5f0"

