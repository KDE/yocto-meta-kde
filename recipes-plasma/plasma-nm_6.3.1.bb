# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.1/plasma-nm-6.3.1.tar.xz"
SRC_URI[sha256sum] = "afc7093b600c315cd1af752f8ad3f7995731a2ffc52fb89b074e2fa88b000064"

