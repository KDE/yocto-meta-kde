# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.0.2/libplasma-6.0.2.tar.xz"
SRC_URI[sha256sum] = "35a02104bdc7dc1347113219768a65366503a7df5faf98bf00d01ab6034d11bd"

