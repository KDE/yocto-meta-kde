# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.92.0/libplasma-5.92.0.tar.xz"
SRC_URI[sha256sum] = "738dcf328e19b02dc25b5ddada675b5240d944302f0c5110126f33187879b9d0"

