# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.4/ocean-sound-theme-6.3.4.tar.xz"
SRC_URI[sha256sum] = "06317dac665aec586d2141237ac6c898d401c5659a4f0d98548b6b9019c4a1ec"

