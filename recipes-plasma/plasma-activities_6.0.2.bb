# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.0.2/plasma-activities-6.0.2.tar.xz"
SRC_URI[sha256sum] = "0a877d0b6715fb1e5848e402e102bd06ebb891ed851cbad7eff8faf164ef31a9"

