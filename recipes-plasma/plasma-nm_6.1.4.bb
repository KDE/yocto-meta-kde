# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.1.4/plasma-nm-6.1.4.tar.xz"
SRC_URI[sha256sum] = "14af47108cf32af68c00d0ce6fb3627f3b4a91e2e057a6ef5ba8fcfcb6f505e1"

