# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.0.2/layer-shell-qt-6.0.2.tar.xz"
SRC_URI[sha256sum] = "aad682c13062868b94970cb60de4001fa8d1a4bdd827c63756e215d0453de550"

