# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.6.5/plasma-pa-6.6.5.tar.xz"
SRC_URI[sha256sum] = "b63c01981ea0d329fd08013eff24b247b60922abe1497be01234660c15cb3826"

