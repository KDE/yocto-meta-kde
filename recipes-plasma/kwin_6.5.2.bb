# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.5.2/kwin-6.5.2.tar.xz"
SRC_URI[sha256sum] = "3be0d569fe342daddee859bab6aefda32d7056b601e84038e8af92593f140774"

