# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.25.1/bluedevil-5.25.1.tar.xz"
SRC_URI[sha256sum] = "6f844bced6ea7ebc84d9db4a6c81abd1dd08dd85326be0ccdd7a9049c5efabb9"

