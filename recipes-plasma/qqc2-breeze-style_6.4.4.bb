# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.4.4/qqc2-breeze-style-6.4.4.tar.xz"
SRC_URI[sha256sum] = "fb73e858d079f0a292ed571558f2cd25ef7e83cbecd15f62f5789540c3b0951c"

