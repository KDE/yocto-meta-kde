# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.4.4/powerdevil-6.4.4.tar.xz"
SRC_URI[sha256sum] = "caaf0b4dc6547c9490f499f46ba3cde750d8f4d393776a1fff652b1be9810028"

