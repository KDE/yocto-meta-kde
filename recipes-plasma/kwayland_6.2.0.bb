# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.0/kwayland-6.2.0.tar.xz"
SRC_URI[sha256sum] = "7ffe0c2b1f82315b6226c50cfb752e6738e576fbf70b7296d1717b3d86226244"

