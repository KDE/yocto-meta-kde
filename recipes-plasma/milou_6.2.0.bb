# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.0/milou-6.2.0.tar.xz"
SRC_URI[sha256sum] = "b1f1b4e13fb40476531b3a63e766a23ef7794de1b8620242b4c51ab445f9b1c5"

