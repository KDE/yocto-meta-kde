# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.92.0/plasma5support-5.92.0.tar.xz"
SRC_URI[sha256sum] = "77fd65179268738a31ebfa0d9f7289197bf3970e7d0ec213032950420f998e7f"

