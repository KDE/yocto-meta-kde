# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.1.4/polkit-kde-agent-1-6.1.4.tar.xz"
SRC_URI[sha256sum] = "78fa994b712aabcdbefdef0c05fafda046ac3ce4e50657d81a3cc30fa25ddbbf"

