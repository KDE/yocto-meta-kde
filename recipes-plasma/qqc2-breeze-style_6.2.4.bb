# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.4/qqc2-breeze-style-6.2.4.tar.xz"
SRC_URI[sha256sum] = "ac02a6db14e539796fc5255f512fa8d6a48e2a4caadac283ef6b190e7047117a"

