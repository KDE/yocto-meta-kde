# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.22.5/libkscreen-5.22.5.tar.xz"
SRC_URI[sha256sum] = "5b4fcaebacc3a4cb62e599a796dca89a30c5ac10937ba3ef9a28998c84ca16e3"

