# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.0/kde-cli-tools-6.2.0.tar.xz"
SRC_URI[sha256sum] = "7be042f98af46ccb5f97358ff9fa58c9303606c9909e1c92ece56247d9d3d2b6"

