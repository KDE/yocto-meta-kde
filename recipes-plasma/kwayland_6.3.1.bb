# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.1/kwayland-6.3.1.tar.xz"
SRC_URI[sha256sum] = "3ae93c046a65425d71020516ca32ada5d97b93e7a42023838c7afdb31dd21a62"

