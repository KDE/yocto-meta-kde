# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.1/kscreenlocker-6.3.1.tar.xz"
SRC_URI[sha256sum] = "c69fe68a95863eaee4140f8cc7e42c832cbc8f610d7c6872b865c890529014e8"

