# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.2/plasma-nm-6.2.2.tar.xz"
SRC_URI[sha256sum] = "8df997bcf14b1031b8b28055a1bcfe22e560eaa4a91ad2a42402b0db8a44c470"

