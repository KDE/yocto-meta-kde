# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.22.5/kactivitymanagerd-5.22.5.tar.xz"
SRC_URI[sha256sum] = "22ab64377d595e0384285d95fe21464ab63a7644d2303cc0002b495f85412a19"

