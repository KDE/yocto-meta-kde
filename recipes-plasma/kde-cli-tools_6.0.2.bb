# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.0.2/kde-cli-tools-6.0.2.tar.xz"
SRC_URI[sha256sum] = "4abec932b4b479a4224e0ef256305598655d3389b369a61fe48637e2b5ce8e55"

