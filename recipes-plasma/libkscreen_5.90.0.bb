# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.90.0/libkscreen-5.90.0.tar.xz"
SRC_URI[sha256sum] = "d16732a0e1eb90dd08272029f311f2742867f582a14cdd13afdf50cb4c8102d4"

