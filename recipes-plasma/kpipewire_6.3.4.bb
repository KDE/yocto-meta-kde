# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.4/kpipewire-6.3.4.tar.xz"
SRC_URI[sha256sum] = "bbfd42737b5968fbc855e974aa68739e87ccd24b0a6e23d71afc0e98a9115458"

