# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.92.0/kscreen-5.92.0.tar.xz"
SRC_URI[sha256sum] = "3124574331bc3bc78054e21a9745c28213481bd4517c44b0775d5cf2c02a7903"

