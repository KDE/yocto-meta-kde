# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.6.5/qqc2-breeze-style-6.6.5.tar.xz"
SRC_URI[sha256sum] = "8d279f966903219721941ea9f41681630dc14fa45769d9c672c57493f6c99603"

