# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.0.2/kdecoration-6.0.2.tar.xz"
SRC_URI[sha256sum] = "b993616cc5d78fce787b2dbd04aafe540e929c2ecccde14bce0c61903514bec2"

