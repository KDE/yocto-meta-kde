# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.24.2/plasma-nano-5.24.2.tar.xz"
SRC_URI[sha256sum] = "bb003d9b63b114142b1e913634822eca23a8cb776221f42799b6e5063a15ad88"

