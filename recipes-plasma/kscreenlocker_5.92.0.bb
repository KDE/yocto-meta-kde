# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.92.0/kscreenlocker-5.92.0.tar.xz"
SRC_URI[sha256sum] = "e568840af812976eae4ccc4dc8c42c80dce6950e120dec26ac409d49b380a597"

