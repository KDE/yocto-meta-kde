# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.4/plasma-workspace-6.2.4.tar.xz"
SRC_URI[sha256sum] = "32aa3bda29d7b76a7dae7e1f8c9789cfe7f609eb878e1a793db4b1490ca3c174"

