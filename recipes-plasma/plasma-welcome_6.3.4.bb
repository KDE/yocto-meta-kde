# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.4/plasma-welcome-6.3.4.tar.xz"
SRC_URI[sha256sum] = "33d552e398f2145f9519056f989de0066cc8fdca6961a309d7a0ace6dcef39b3"

