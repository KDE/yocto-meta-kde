# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.0.2/kglobalacceld-6.0.2.tar.xz"
SRC_URI[sha256sum] = "a4f3c6d8c08636e8c0238c5b9455a0c975d57225c66127326d1dd4dda1a3268b"

