# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/5.27.4/plasma-remotecontrollers-5.27.4.tar.xz"
SRC_URI[sha256sum] = "368c29c42676b0e4d1e17e371d8ce09671081d4e37432e40f7401c1406063651"

