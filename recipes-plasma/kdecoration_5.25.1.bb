# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.25.1/kdecoration-5.25.1.tar.xz"
SRC_URI[sha256sum] = "632c410dc46f28d507aeea73665e11cf4abdfaba63cbd36a160e9c019898f195"

