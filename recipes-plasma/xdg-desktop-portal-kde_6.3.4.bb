# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.4/xdg-desktop-portal-kde-6.3.4.tar.xz"
SRC_URI[sha256sum] = "59c62f679d2dac721dd537d83ad3075c129d07e1056e0a592117f711979f0821"

