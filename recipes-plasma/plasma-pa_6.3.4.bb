# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.4/plasma-pa-6.3.4.tar.xz"
SRC_URI[sha256sum] = "2bb964e29b7a37f2a5b3787ce573347a9adbfb889eba49c99404be444f5e9b99"

