# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.0/plasma-desktop-6.2.0.tar.xz"
SRC_URI[sha256sum] = "0ea38e20b9c4163857db920ea80c9740a29e561886b5feb9f20f938598692709"

