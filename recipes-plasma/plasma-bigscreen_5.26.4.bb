# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.26.4/plasma-bigscreen-5.26.4.tar.xz"
SRC_URI[sha256sum] = "ba546660c4efdad8e2f09e4331fea4f98fbe86d7d17cf2f767186de3d981d64d"

