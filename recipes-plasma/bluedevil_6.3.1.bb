# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.1/bluedevil-6.3.1.tar.xz"
SRC_URI[sha256sum] = "a91358cc64aceace9273c2939ce325c913aeedfe896f53581c9ec4087258ffab"

