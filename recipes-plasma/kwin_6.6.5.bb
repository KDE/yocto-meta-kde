# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.6.5/kwin-6.6.5.tar.xz"
SRC_URI[sha256sum] = "6c187ce7a5506090b438ef900103836fa0537674dde8b31e5b497ef321643cb4"

