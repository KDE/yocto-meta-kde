# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.1.4/plasma-welcome-6.1.4.tar.xz"
SRC_URI[sha256sum] = "a4adb679fe9c75cddc5153a6313809a11b4c4719dd10590d044d2935c7d53b7e"

