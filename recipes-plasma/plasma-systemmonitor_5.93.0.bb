# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.93.0/plasma-systemmonitor-5.93.0.tar.xz"
SRC_URI[sha256sum] = "0065593dbaec47a993edcd916e30367e20523d00f0a30293e79d842e07cca989"

