# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.93.0/kactivitymanagerd-5.93.0.tar.xz"
SRC_URI[sha256sum] = "b407e083f6a408d56f4b8293d8d12b71f1908b4986f052a240a5303d41cb5875"

