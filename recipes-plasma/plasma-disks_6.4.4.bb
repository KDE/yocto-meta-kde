# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.4.4/plasma-disks-6.4.4.tar.xz"
SRC_URI[sha256sum] = "38f984261fb84b03e7c37ddf8b5fb9cb34644e714a6b547c14771aa5458bfaa0"

