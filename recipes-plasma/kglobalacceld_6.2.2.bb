# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.2/kglobalacceld-6.2.2.tar.xz"
SRC_URI[sha256sum] = "4cc44449c445d5ef251cd0a06e18480a4b780fecafd3c6c5fba758a56f7ece6c"

