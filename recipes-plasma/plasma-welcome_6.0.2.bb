# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.0.2/plasma-welcome-6.0.2.tar.xz"
SRC_URI[sha256sum] = "3d98ae45905c84cea458d62680a1c2471d44d19bb61ce931e3b20d05f0f0f74f"

