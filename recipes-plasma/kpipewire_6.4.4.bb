# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.4.4/kpipewire-6.4.4.tar.xz"
SRC_URI[sha256sum] = "097f9971580cc7ce3bd89e73ced7606e3978347bd44131d6744fe02d8a1b3ea6"

