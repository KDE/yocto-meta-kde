# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.1.3/qqc2-breeze-style-6.1.3.tar.xz"
SRC_URI[sha256sum] = "4947312e1e7282923dfabfe6c6db60e90c3cf4c329092cb7d077f7184551be68"

