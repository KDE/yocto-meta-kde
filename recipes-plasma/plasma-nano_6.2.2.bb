# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.2/plasma-nano-6.2.2.tar.xz"
SRC_URI[sha256sum] = "5c6c46bd3cc901f6adbc0bf369853de9834ec2cb6f8565501815dd72ff6e87cc"

