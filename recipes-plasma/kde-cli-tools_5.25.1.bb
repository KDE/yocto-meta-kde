# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.25.1/kde-cli-tools-5.25.1.tar.xz"
SRC_URI[sha256sum] = "28859ea6adc48b8b934edbaef4ef526644d7403b9cfd83245653728f88e6670f"

