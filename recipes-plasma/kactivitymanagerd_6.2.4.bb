# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.4/kactivitymanagerd-6.2.4.tar.xz"
SRC_URI[sha256sum] = "17672c65500c731eeb3c43649cf52ecae115adfd1942c24599055ece3e4a90da"

