# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.2/plasma-mobile-6.2.2.tar.xz"
SRC_URI[sha256sum] = "0c2a3ed787dabf58b515c7733cda9e07ad5bf7737bf8497db3bfea90d8c967a2"

