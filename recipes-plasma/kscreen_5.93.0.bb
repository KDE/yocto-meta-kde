# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.93.0/kscreen-5.93.0.tar.xz"
SRC_URI[sha256sum] = "640b01405105f16a5c4973709185bb48fb1ed33b263617f78b4190dbba877665"

