# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.27.0/plasma-pa-5.27.0.tar.xz"
SRC_URI[sha256sum] = "74f2f0ba643667a67888ff2cd7acde86b9143746e2375d04483e79941d93767c"

