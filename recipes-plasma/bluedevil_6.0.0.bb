# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.0.0/bluedevil-6.0.0.tar.xz"
SRC_URI[sha256sum] = "831473069c7bf07187af2acbb101d3a6c74755587e490142098d5aa054ee6265"

