# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.4/kscreenlocker-6.3.4.tar.xz"
SRC_URI[sha256sum] = "4667ef3fac7dd440a56b4af251bf5a4a7e84075ef2d616d34ae3358624c0e946"

