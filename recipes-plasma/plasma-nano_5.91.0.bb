# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.91.0/plasma-nano-5.91.0.tar.xz"
SRC_URI[sha256sum] = "8c888c09649bc515a1e6d36306f937515381e1c0e23f2cc67fee01f7c1e2a9c1"

