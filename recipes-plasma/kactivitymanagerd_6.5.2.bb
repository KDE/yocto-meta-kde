# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.5.2/kactivitymanagerd-6.5.2.tar.xz"
SRC_URI[sha256sum] = "9332b5f0fc86f806a480bb45112693a83df906db8eaddc2417459e9a6d7cdf6d"

