# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/5.27.4/plank-player-5.27.4.tar.xz"
SRC_URI[sha256sum] = "b674b85541751a5a33a3ade38fe9ccf27884d71d48290656a2766d4b88d9a018"

