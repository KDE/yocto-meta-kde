# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.27.0/kscreen-5.27.0.tar.xz"
SRC_URI[sha256sum] = "fc85b5e1f0a9e365ba4ac4bd1d36a86e24c743aa85a8ba1cee649a4905046f10"

