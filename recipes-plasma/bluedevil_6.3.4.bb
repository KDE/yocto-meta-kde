# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.4/bluedevil-6.3.4.tar.xz"
SRC_URI[sha256sum] = "559b70b1b2678239f68a22039472e9076e6e302e039e7255a440d48573c70fba"

