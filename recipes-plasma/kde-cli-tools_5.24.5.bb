# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.24.5/kde-cli-tools-5.24.5.tar.xz"
SRC_URI[sha256sum] = "e7f0dd3469b7b3152e72514f1f6ce544514067011ebd0137cb0957d37ad6d329"

