# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.5.2/plasma-pa-6.5.2.tar.xz"
SRC_URI[sha256sum] = "85178649dfb37f65d838de54151b13f0a145c417acc879b53f62f4a6d2f041a1"

