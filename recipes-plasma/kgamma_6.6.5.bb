# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.6.5/kgamma-6.6.5.tar.xz"
SRC_URI[sha256sum] = "fab70445c88c98ce907e896d8c71cbf7771044880b5ef116fee969863e53360a"

