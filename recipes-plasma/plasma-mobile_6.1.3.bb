# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.1.3/plasma-mobile-6.1.3.tar.xz"
SRC_URI[sha256sum] = "e00e5d60914387a78c0eaf8906e49f8c5c0e685deefd947b601e26296ba8bc02"

