# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.90.0/kdecoration-5.90.0.tar.xz"
SRC_URI[sha256sum] = "63120fe05aea12fd519fcae9bfbfdd5f6efc3fdebcf1eeae446f01c284f4f16e"

