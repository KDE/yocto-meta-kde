# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.5.2/ocean-sound-theme-6.5.2.tar.xz"
SRC_URI[sha256sum] = "7e3bb59309e54f8aa3e6303a70dac0eba91662e0a0709d041fd073722f06ee91"

