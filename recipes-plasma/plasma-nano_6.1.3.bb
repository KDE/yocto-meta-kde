# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.1.3/plasma-nano-6.1.3.tar.xz"
SRC_URI[sha256sum] = "236c5dddcb51a22b142242125785edfb86c5a4b1aca9bcb5d57bea4b52128898"

