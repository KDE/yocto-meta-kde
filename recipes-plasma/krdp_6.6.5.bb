# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.6.5/krdp-6.6.5.tar.xz"
SRC_URI[sha256sum] = "85e35131f640c269f8db6b2f858fb043f6f6266b1f65030129d110c0adcb8061"

