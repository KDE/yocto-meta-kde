# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.22.5/kwayland-integration-5.22.5.tar.xz"
SRC_URI[sha256sum] = "4cbc301227a507fb2ac42e08130c79ff58a9905ebd444ddd64c78bb1e834fb4d"

