# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.92.0/kwin-5.92.0.tar.xz"
SRC_URI[sha256sum] = "c4a167fe6cc613fa6fd73c3697b1d925c42fdc717531a346e0005ba5aef4c17e"

