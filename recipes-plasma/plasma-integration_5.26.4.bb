# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.26.4/plasma-integration-5.26.4.tar.xz"
SRC_URI[sha256sum] = "5e63c1ee25dc37788bd633eeae7ba96bac8fc2a79ce021a5d04250ca749fbf3d"

