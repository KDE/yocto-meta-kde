# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "git://anongit.kde.org/bluedevil;nobranch=1;protocol=https"
SRCREV = "d7f81d374e1bb897d3333f35ccd62b49eb7ceafe"
S = "${WORKDIR}/git"
