# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.4/plasma5support-6.2.4.tar.xz"
SRC_URI[sha256sum] = "233bbdc3f1c0b8acbb710f53c6308359c315b699958f6784b3467f4724f93d8d"

