# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.4/kgamma-6.2.4.tar.xz"
SRC_URI[sha256sum] = "73a745fc66cd14eaa6e13350c38683a5045125887a18f461eb2b64e50e6a1922"

