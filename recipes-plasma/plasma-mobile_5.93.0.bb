# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.93.0/plasma-mobile-5.93.0.tar.xz"
SRC_URI[sha256sum] = "f04bfacea3bbf05852c2e205e56f7dc94dbe959c79686275729bedae9b9eda42"

