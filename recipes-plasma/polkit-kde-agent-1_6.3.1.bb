# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.1/polkit-kde-agent-1-6.3.1.tar.xz"
SRC_URI[sha256sum] = "f8acd2570de8937605d57171017896575b86f2d5d56e6088ede73f106d9f0bb2"

