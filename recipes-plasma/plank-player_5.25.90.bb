# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "git://anongit.kde.org/plank-player;nobranch=1;protocol=https"
SRCREV = "0d21c5dfe2ebea2cd55735974afc4413365200e2"
S = "${WORKDIR}/git"
