# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.1.3/kpipewire-6.1.3.tar.xz"
SRC_URI[sha256sum] = "eb2217024e3bf3a4777548b9a0bda88ca0b97912d20336b03f5942b28b1baef9"

