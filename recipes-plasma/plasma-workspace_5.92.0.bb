# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.92.0/plasma-workspace-5.92.0.tar.xz"
SRC_URI[sha256sum] = "bbe200ff10d5dafb274204da5e6e57db2b012364a1abd32f1e1da23b76cd6b94"

