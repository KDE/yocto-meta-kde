# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.1.4/plasma-mobile-6.1.4.tar.xz"
SRC_URI[sha256sum] = "949b05d41c05a5a74e4b7aaaa05060fc1e4069b38f4fcec06c29cbcbf92330d2"

