# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.25.1/systemsettings-5.25.1.tar.xz"
SRC_URI[sha256sum] = "438e656ff819916c9de35cb69830b299cf25d5b88db0f8699d235b5de1822cce"

