# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.1/kwallet-pam-6.3.1.tar.xz"
SRC_URI[sha256sum] = "7e8d55ead94033d611819d68c8b9d01535f68b46b5855cadb18014e4f7ab45fc"

