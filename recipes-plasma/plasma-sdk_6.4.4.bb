# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.4.4/plasma-sdk-6.4.4.tar.xz"
SRC_URI[sha256sum] = "f10c7aec9f2a26b6f8a04d3ea1e11e8851baf3918fd93a1b7cef07f935a4096c"

