# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.93.0/kwayland-5.93.0.tar.xz"
SRC_URI[sha256sum] = "cad4fa9a57467cb1fbb4fca83729fa5417e5399e17eb323a4d8de1c62448e01a"

