# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/5.27.4/breeze-5.27.4.tar.xz"
SRC_URI[sha256sum] = "62d80ebd690c7822bf05b19bec8b37af67cc1cd4bb3f38d2a88d8360fd6b1901"

