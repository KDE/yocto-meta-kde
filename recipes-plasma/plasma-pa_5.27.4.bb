# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/5.27.4/plasma-pa-5.27.4.tar.xz"
SRC_URI[sha256sum] = "ed344553bd7516579f0c647414811f46b19789ebf4f5544181299ee52ad3f2e6"

