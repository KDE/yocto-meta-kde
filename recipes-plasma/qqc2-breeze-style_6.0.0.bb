# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.0.0/qqc2-breeze-style-6.0.0.tar.xz"
SRC_URI[sha256sum] = "a430e197c213c4989fe10fc249e4f0ae462ee1d3f5d6fbc958f42eb38b04c927"

