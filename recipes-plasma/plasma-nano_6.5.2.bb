# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.5.2/plasma-nano-6.5.2.tar.xz"
SRC_URI[sha256sum] = "c23cd68410aa53b08099684f0c2838447db81615fbf68da937de6e5b8554b203"

