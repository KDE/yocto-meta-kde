# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.6.5/breeze-6.6.5.tar.xz"
SRC_URI[sha256sum] = "06c4c3e466cd03a8c1e411a38b04756b6e145879a560534b2fc44666d41330f4"

