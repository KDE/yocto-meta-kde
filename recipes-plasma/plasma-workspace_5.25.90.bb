# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "git://anongit.kde.org/plasma-workspace;nobranch=1;protocol=https"
SRCREV = "e660f464ef5b88d41397bbcc523b6b9e704208a7"
S = "${WORKDIR}/git"
