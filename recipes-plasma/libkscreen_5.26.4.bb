# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.26.4/libkscreen-5.26.4.tar.xz"
SRC_URI[sha256sum] = "bb0252f6b8ac52ca6066d127fb3dbb782ef864a8ac60f66c03cb3c81c78378f0"

