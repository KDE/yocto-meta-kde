# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.4/kwin-6.3.4.tar.xz"
SRC_URI[sha256sum] = "e74a61eccc5d3248dbd620b6c2c7b175013b15ff59e17af70f88aefc082445a5"

