# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.1.3/layer-shell-qt-6.1.3.tar.xz"
SRC_URI[sha256sum] = "a201bd3c867130e96cae75dcfec07f82af74dc2e8074d8d1bd9b0ae2645bf802"

