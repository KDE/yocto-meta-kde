# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.27.0/systemsettings-5.27.0.tar.xz"
SRC_URI[sha256sum] = "2715bfa6df9810dee9961bb626cc0d644e96e1b81b9213af3fadb09467d8ba6a"

