# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.4/plasma5support-6.3.4.tar.xz"
SRC_URI[sha256sum] = "da5276d01e7c249b6b9144235b3a7822e74a6f9f7efd7900532fa21d6444bd84"

