# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.25.1/plasma-nano-5.25.1.tar.xz"
SRC_URI[sha256sum] = "dec13e02b67f20bec8291843a724f8fe27a45155064cfa9ce699cc8931fa8d29"

