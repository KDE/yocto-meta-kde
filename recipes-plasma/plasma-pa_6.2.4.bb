# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.4/plasma-pa-6.2.4.tar.xz"
SRC_URI[sha256sum] = "276575b381c26080279a5acf87af6425026d2eebe1a906507383f5f09e681a57"

