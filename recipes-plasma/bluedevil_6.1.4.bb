# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.1.4/bluedevil-6.1.4.tar.xz"
SRC_URI[sha256sum] = "70f8e95cc9b591204e823278924047a9e3965b0385bf9a12220132e6c00c140f"

