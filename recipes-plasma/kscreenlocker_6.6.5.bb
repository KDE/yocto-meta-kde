# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.6.5/kscreenlocker-6.6.5.tar.xz"
SRC_URI[sha256sum] = "9ba0aee32364051eeb213d48dd3c208ae0ce7062190a30f855735ba4efe389cc"

