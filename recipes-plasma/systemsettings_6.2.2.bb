# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.2/systemsettings-6.2.2.tar.xz"
SRC_URI[sha256sum] = "a5399e1ddab5d86c4cf7c63c34d7cca7599b1b6ce38cbca9d4056022cf4a4844"

