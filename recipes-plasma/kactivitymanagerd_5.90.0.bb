# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.90.0/kactivitymanagerd-5.90.0.tar.xz"
SRC_URI[sha256sum] = "243787eedd0b85acf6d6fa0d4c680033e69617489584fb4fb9f6e1e7dc12df44"

