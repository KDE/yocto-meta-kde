# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.24.2/milou-5.24.2.tar.xz"
SRC_URI[sha256sum] = "9a8c4b0561ce85f37ccd4500b715c73b9ed77aec79aa46eb2b0e04d9b94381e4"

