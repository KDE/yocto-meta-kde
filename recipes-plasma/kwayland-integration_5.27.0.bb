# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.27.0/kwayland-integration-5.27.0.tar.xz"
SRC_URI[sha256sum] = "1b3bff453176d37fedd3ddb7bb69c978fc42c48f6324737d94b9aa644311b42a"

