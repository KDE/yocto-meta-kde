# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.0.0/plasma-nano-6.0.0.tar.xz"
SRC_URI[sha256sum] = "99fc44ded4dd3b44c45f893ed9221aa6126dde9d4f6adcb72704c03a93207c27"

