# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.90.0/plasma5support-5.90.0.tar.xz"
SRC_URI[sha256sum] = "c910d9addd62c4c1ffefb7ab5476418ae8b179e42c4b259a4fe3e80da95b8bfb"

