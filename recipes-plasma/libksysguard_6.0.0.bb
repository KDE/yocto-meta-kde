# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.0.0/libksysguard-6.0.0.tar.xz"
SRC_URI[sha256sum] = "6b72ccfbed69f27bcec0d86414ed780870109801cc20c505901657c85c3644dd"

