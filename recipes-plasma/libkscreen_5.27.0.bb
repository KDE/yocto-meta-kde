# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.27.0/libkscreen-5.27.0.tar.xz"
SRC_URI[sha256sum] = "50605ae2c1a2d36a24293c87010f94cc39437d20325e5479b722b8e71e926299"

