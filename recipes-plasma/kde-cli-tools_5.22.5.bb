# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.22.5/kde-cli-tools-5.22.5.tar.xz"
SRC_URI[sha256sum] = "90cb373ea112b844541d9c52000635b02ccdf2fe2da0fc7901b1a5a8b8df45ca"

