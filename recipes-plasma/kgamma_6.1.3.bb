# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.1.3/kgamma-6.1.3.tar.xz"
SRC_URI[sha256sum] = "aded428452f081141613f46748b56c907850aa305573b06929fba94ea0de535b"

