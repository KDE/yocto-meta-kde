# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.2/kwin-6.2.2.tar.xz"
SRC_URI[sha256sum] = "fb5c2ff3e8007722f3fa528872e6494dc21d48c8a6b632b748486389486bc061"

