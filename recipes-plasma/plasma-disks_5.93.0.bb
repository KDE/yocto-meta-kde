# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.93.0/plasma-disks-5.93.0.tar.xz"
SRC_URI[sha256sum] = "116def373c1fe16ea4bcd7a721405553990937aeee311a78401ad9bd0c61a027"

