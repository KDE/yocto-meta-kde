# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.1.3/plasma-vault-6.1.3.tar.xz"
SRC_URI[sha256sum] = "d014f20f02ce6c6289f5412db685996c3ccfa704a1e6c7b22e5b342ea0441b70"

