# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.24.2/kde-cli-tools-5.24.2.tar.xz"
SRC_URI[sha256sum] = "9549c0474695df4855b66ee2196caa14a0bc3e0179920ae564d149bc5ecf6984"

