# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.22.5/plasma-nano-5.22.5.tar.xz"
SRC_URI[sha256sum] = "50ba3ec6f8619936fdac8bf2eff03e595828e8b7c2f7e5adcb8001e07a451945"

