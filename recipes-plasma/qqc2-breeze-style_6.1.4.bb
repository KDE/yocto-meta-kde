# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.1.4/qqc2-breeze-style-6.1.4.tar.xz"
SRC_URI[sha256sum] = "8fb9bc4156f9dc920c63b0d8afaa4aacb72eb650e907c06dacde38bfd55d5168"

