# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.4/libkscreen-6.3.4.tar.xz"
SRC_URI[sha256sum] = "aced15601115acbd4009c2bc6bd445456fc21c1d046dee1641f22520eeb9ec3c"

