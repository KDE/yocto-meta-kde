# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.90.0/plasma-pa-5.90.0.tar.xz"
SRC_URI[sha256sum] = "afc17d4996eef0c14324987876d05a451dd7778822e59d3c7b1c64e59791c3ad"

