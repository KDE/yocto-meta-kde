# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.1.3/breeze-6.1.3.tar.xz"
SRC_URI[sha256sum] = "f15bba8dded07595534656de7ab0dbac9b0cdee8462d53aaaa309b3cf2d576d1"

