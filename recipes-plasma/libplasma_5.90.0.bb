# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.90.0/libplasma-5.90.0.tar.xz"
SRC_URI[sha256sum] = "aa99703d6434816b669c2c37a031110df40facc022d803211d39805c6d4a78e0"

