# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.1.4/kwin-6.1.4.tar.xz"
SRC_URI[sha256sum] = "fcffce468dea23a92cad33ac1b1264c55c0799d497f54f6b8e23439dcdadeb3a"

