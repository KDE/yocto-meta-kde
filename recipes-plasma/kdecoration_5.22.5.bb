# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.22.5/kdecoration-5.22.5.tar.xz"
SRC_URI[sha256sum] = "b577202eefaad7b95e701c1ce14108fbfe4ae6fd73ce46c369a2a7a329211bef"

