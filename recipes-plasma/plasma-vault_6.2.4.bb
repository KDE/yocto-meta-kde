# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.4/plasma-vault-6.2.4.tar.xz"
SRC_URI[sha256sum] = "ca9934d3ca2fe55633c429302068f81778bf4a62e22059ee2b6aa0950e9686c3"

