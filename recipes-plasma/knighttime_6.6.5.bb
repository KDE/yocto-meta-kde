# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.6.5/knighttime-6.6.5.tar.xz"
SRC_URI[sha256sum] = "5f26692a864540b993351106f5469fd17939bd55e79f931c8f97395d9c5a809d"

