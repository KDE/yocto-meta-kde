# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.91.0/discover-5.91.0.tar.xz"
SRC_URI[sha256sum] = "35f0c159147c34ad67f8955d623f2a49f2ccc8dd888bb5f35ea810ad14351e9b"

