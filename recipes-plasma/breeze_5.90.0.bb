# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.90.0/breeze-5.90.0.tar.xz"
SRC_URI[sha256sum] = "4cb72caf869687f841f86a652885ba21fd5db9c0c5e08accc98531457d0117a1"

