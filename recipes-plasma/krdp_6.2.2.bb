# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.2/krdp-6.2.2.tar.xz"
SRC_URI[sha256sum] = "053962b2192c549962348bcd01c2ac84ef4f964dcafa1b4f6d6735b610a1ca72"

