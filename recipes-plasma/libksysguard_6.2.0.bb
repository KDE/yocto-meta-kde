# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.0/libksysguard-6.2.0.tar.xz"
SRC_URI[sha256sum] = "0286a90d0ae1a856efec05cd3a34b695fb2521a3b5b56af2d900c19950228278"

