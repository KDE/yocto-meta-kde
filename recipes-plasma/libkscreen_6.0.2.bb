# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.0.2/libkscreen-6.0.2.tar.xz"
SRC_URI[sha256sum] = "2f865c9589b60ae7395b18a531b1e6fbfea8e2ce5c147811b0ef1f8c05e30537"

