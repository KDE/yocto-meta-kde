# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.1/xdg-desktop-portal-kde-6.3.1.tar.xz"
SRC_URI[sha256sum] = "ff29e40552db6fab6f2717f9742b605983c6a9e0edbf360421de19003a5e9567"

