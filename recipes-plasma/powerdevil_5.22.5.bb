# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.22.5/powerdevil-5.22.5.tar.xz"
SRC_URI[sha256sum] = "597301e6520c17131c98a98960a1e3b7827e63ab9efed0fea5340203133f1c9f"

