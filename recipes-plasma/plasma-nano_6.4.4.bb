# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.4.4/plasma-nano-6.4.4.tar.xz"
SRC_URI[sha256sum] = "cfd8df2f9d82358247c4ae7eb97acd585532faeb26b51a5e4db90cd85e7a1a2e"

