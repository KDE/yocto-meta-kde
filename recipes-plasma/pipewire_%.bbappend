PACKAGECONFIG:append = " ffmpeg"
