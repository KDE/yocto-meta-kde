# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.27.0/kwin-5.27.0.tar.xz"
SRC_URI[sha256sum] = "2cf12150d18b4509fefc528eb3d63be8010ea20b46e9897703211a3d87aa39bc"

