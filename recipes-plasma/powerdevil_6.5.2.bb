# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.5.2/powerdevil-6.5.2.tar.xz"
SRC_URI[sha256sum] = "7cfeb08beb3cc44ac6ae525613cdf40855dd1137083b050dc5e65d3764cbf4cb"

