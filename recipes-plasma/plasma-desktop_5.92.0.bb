# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.92.0/plasma-desktop-5.92.0.tar.xz"
SRC_URI[sha256sum] = "4df4a24a6acd8962b5377685dfb4dae668a6e4c50a353f6ee84cf4ee1d96e823"

