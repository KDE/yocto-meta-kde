# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.0.2/kwin-6.0.2.tar.xz"
SRC_URI[sha256sum] = "65340620154fede598daa76cc624739a9824685aa1aa94224efdd5f1b9b076bb"

