# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.90.0/powerdevil-5.90.0.tar.xz"
SRC_URI[sha256sum] = "540e1dfe5c906c78b5d198977dc28525da89f0b0934f3cb4c4adaeeeb1f6afff"

