# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.0/kwin-6.2.0.tar.xz"
SRC_URI[sha256sum] = "8ae8852e48c042e96f98e76a8b67f7e94f1d601939336fba7f8db8b43bf2fcba"

