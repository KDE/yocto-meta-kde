# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.4/plasma-firewall-6.2.4.tar.xz"
SRC_URI[sha256sum] = "9ab70848d0616f08e4f27bb31c23746aa35d800d9b748291eaa078dd19993d55"

