# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/5.27.4/plasma-nm-5.27.4.tar.xz"
SRC_URI[sha256sum] = "2ee6bff818e5168062e1e4358851697e4397d8b666e4a58a4883489c1a51214b"

