# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.0/kactivitymanagerd-6.2.0.tar.xz"
SRC_URI[sha256sum] = "eb943611d85d18ac5793c3bc81b97b7507af97034df0386d9bd0e39999e6e06c"

