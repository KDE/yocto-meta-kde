# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.5.2/kscreen-6.5.2.tar.xz"
SRC_URI[sha256sum] = "9c814fd42f9730196fc0c9e6230a85bfc8004c0e5732b04879d35db4d7b9c468"

