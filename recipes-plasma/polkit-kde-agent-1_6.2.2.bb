# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.2/polkit-kde-agent-1-6.2.2.tar.xz"
SRC_URI[sha256sum] = "3510353360dec75c47d60528d6550a6afca91d97d466e35a4dfdb254fe6cf5ea"

