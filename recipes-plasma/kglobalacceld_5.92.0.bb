# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.92.0/kglobalacceld-5.92.0.tar.xz"
SRC_URI[sha256sum] = "feb35c9b4a06bf9079a00d0d180ad170e69133e6a66670c2ce165cd8663224b4"

