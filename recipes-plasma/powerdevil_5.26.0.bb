# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.26.0/powerdevil-5.26.0.tar.xz"
SRC_URI[sha256sum] = "76ee034a1515c3af2692c4f3cda0719195acf22f0872de852d2b0b6ede2cf0ae"

