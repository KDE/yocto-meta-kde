# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.1/plasma-systemmonitor-6.3.1.tar.xz"
SRC_URI[sha256sum] = "ae0b9f01484897013c0ece4d5f2fb0023da8c7f2439c28ed7cf039049ad71bba"

