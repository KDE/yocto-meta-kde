# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.92.0/kdecoration-5.92.0.tar.xz"
SRC_URI[sha256sum] = "a9af0b4a78e5f4fee3dcf5fd75160c149324709bce94a6537b92e62cf0c76614"

