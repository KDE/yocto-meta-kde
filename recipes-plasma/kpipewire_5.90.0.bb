# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.90.0/kpipewire-5.90.0.tar.xz"
SRC_URI[sha256sum] = "631f410de2fb25e12dda1c5b2d885af584a92bdde271bb3628113575b7840e5c"

