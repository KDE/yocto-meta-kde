# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.91.0/polkit-kde-agent-1-5.91.0.tar.xz"
SRC_URI[sha256sum] = "56c243998a294df1d1ffb210368fe66fd712b78daaf9510b7c65e6316114973e"

