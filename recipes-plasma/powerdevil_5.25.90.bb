# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "git://anongit.kde.org/powerdevil;nobranch=1;protocol=https"
SRCREV = "0af5df1aa5143ed8cf0a799d79416bfa8d659ee2"
S = "${WORKDIR}/git"
