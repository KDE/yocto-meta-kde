# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.2/plasma-sdk-6.2.2.tar.xz"
SRC_URI[sha256sum] = "4f3fca28c148edc1c096688a0a10822187d7a262416a41d404b483b8c2c0620e"

