# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.1/plasma-pa-6.3.1.tar.xz"
SRC_URI[sha256sum] = "b6c5c40133438f1aea4abc2808dc20125f1df17a940156ce77ae6f195d49b548"

