# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.91.0/layer-shell-qt-5.91.0.tar.xz"
SRC_URI[sha256sum] = "3e37efa71e87a5a576f8ae8a028ef9921ff36b275900d07a31094df39f58dc08"

