# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.25.1/plasma-pa-5.25.1.tar.xz"
SRC_URI[sha256sum] = "a1a55baa64ce00214087d312294ed4b673a80509a77abfe2683ac826dce03adb"

