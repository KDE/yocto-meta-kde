# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.93.0/libkscreen-5.93.0.tar.xz"
SRC_URI[sha256sum] = "3aad68acc0089b9f5142cea2f08bc18dcb7f78b95f9f66e57efc8f6de4423913"

