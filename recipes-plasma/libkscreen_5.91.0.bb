# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.91.0/libkscreen-5.91.0.tar.xz"
SRC_URI[sha256sum] = "b25411f405e7bada79567a86d49d47defd0e029572372a8a9bfd4674c8f7f437"

