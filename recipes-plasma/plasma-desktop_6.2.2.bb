# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.2/plasma-desktop-6.2.2.tar.xz"
SRC_URI[sha256sum] = "c83fe62392b23997944ba90959ceae77b3b4b2e6b021223defdad3681d30ae4f"

