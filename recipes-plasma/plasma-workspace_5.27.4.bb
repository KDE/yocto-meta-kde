# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/5.27.4/plasma-workspace-5.27.4.tar.xz"
SRC_URI[sha256sum] = "ead5bfb78a7126360c431f33e2019767909b877ea2910207b8bf67cac9be5bc9"

