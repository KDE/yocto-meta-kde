# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.25.1/milou-5.25.1.tar.xz"
SRC_URI[sha256sum] = "09cc5c0184e1c8e37a3b0e7ba8073dff065615ae8f8c7b469f439ab48c68862a"

