# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.5.2/plasma-welcome-6.5.2.tar.xz"
SRC_URI[sha256sum] = "8098674a8fb4cb2725dc3c070e897d847047695936159b0048d5d5d1a0369563"

