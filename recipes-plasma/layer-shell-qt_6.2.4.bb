# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.4/layer-shell-qt-6.2.4.tar.xz"
SRC_URI[sha256sum] = "001897a7d4991a9e95be73152d9513662cc7d8a53211702d906d597b73ced872"

