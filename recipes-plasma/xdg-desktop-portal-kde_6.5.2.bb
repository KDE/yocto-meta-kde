# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.5.2/xdg-desktop-portal-kde-6.5.2.tar.xz"
SRC_URI[sha256sum] = "6a2e9dc2ed1057df8368023ea3698acf3092e4dee31dfff30b95fa81bd7ab249"

