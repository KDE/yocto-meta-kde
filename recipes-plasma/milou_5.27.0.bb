# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.27.0/milou-5.27.0.tar.xz"
SRC_URI[sha256sum] = "7ddd4a8fce239c62b03ea8963ee1139b17a35d1aa29725995f1fdfccceb045ff"

