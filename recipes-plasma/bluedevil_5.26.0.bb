# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.26.0/bluedevil-5.26.0.tar.xz"
SRC_URI[sha256sum] = "b275b33094961f84310de6d37a5ba197bd34f10f1807ee0462ffbfde8fdc23af"

