# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.4/kwallet-pam-6.3.4.tar.xz"
SRC_URI[sha256sum] = "d7ae0c5baa52de0f8a7dce606512455b94307a3fc0c21d3879dfe631754ea309"

