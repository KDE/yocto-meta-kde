# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.26.0/libksysguard-5.26.0.tar.xz"
SRC_URI[sha256sum] = "43b2f473edc4680511386674582a25f1261cefd19091253a58b9e1eb8d529296"

