# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.0.0/plasma-activities-6.0.0.tar.xz"
SRC_URI[sha256sum] = "f0bd07bbcd9022c72e564046046029b39f71d1cc5b467b9f50914813043b2795"

