# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.27.0/plank-player-5.27.0.tar.xz"
SRC_URI[sha256sum] = "c27796c91c82e6f9e47f71f4162b03b2738a763e847d6c399da56e77593be959"

