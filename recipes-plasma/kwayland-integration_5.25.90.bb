# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "git://anongit.kde.org/kwayland-integration;nobranch=1;protocol=https"
SRCREV = "094150cc5a2df2b8b120d0823840d52369c1d9bb"
S = "${WORKDIR}/git"
