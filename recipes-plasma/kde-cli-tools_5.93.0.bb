# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.93.0/kde-cli-tools-5.93.0.tar.xz"
SRC_URI[sha256sum] = "8c72d7463357ff933953782e563409c7c3ff6e622fb4cf14fe0402b95fc57969"

