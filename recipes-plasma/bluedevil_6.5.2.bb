# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.5.2/bluedevil-6.5.2.tar.xz"
SRC_URI[sha256sum] = "48c3b46b7990a4cf85fa9d07031e6e664219038866977922ee4864b7e7dc43b0"

