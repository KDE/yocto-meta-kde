# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.91.0/plasma-mobile-5.91.0.tar.xz"
SRC_URI[sha256sum] = "bdfc28ed2ddb9d04b83835a5eebd4e7dc2a738f11b55b2937dc34fb30eb33245"

