# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.4.4/layer-shell-qt-6.4.4.tar.xz"
SRC_URI[sha256sum] = "84b31a3e73b150fa611fb51150987600eddd0edc578888e953e7fd37f550643d"

