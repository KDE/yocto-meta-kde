# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.27.80/breeze-5.27.80.tar.xz"
SRC_URI[sha256sum] = "7b6c6909436254077556da45b17136e2e7777709b12bace376de1e56995c80cc"

