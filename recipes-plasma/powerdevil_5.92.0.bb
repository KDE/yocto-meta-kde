# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.92.0/powerdevil-5.92.0.tar.xz"
SRC_URI[sha256sum] = "ff7d88fd0af4505e9fcd0ad40560fb5ff21ae07bb25f4e1f14a05f816b075941"

