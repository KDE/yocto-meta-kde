# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.1.3/systemsettings-6.1.3.tar.xz"
SRC_URI[sha256sum] = "65ba04f22ab4dbfeb8c9a06b540b2ea9d56fe7e9ba295344a5c7e6b63f182131"

