# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.2/powerdevil-6.2.2.tar.xz"
SRC_URI[sha256sum] = "4006f2f49574c4e0036bb25bd3b1a1e5c47a521b26806fa4030d8073fdb17bd9"

