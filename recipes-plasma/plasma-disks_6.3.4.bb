# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.4/plasma-disks-6.3.4.tar.xz"
SRC_URI[sha256sum] = "e58b16fb3f6129fb62b4fa1046509a59a1d5a950bdbc4ba44defee98e0f1dd47"

