# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.1.4/ocean-sound-theme-6.1.4.tar.xz"
SRC_URI[sha256sum] = "a20004cfacb8b0dce9e5deb72d755ee96bfd18eb7307a0a1b829c32fdca56f5c"

