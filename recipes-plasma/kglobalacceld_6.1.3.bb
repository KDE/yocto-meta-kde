# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.1.3/kglobalacceld-6.1.3.tar.xz"
SRC_URI[sha256sum] = "359155f3454948f2717ae6785ed1e6dc2dc8c281e6526cb06852cf4aa1a2a062"

