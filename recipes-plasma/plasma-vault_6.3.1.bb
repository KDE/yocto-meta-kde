# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.1/plasma-vault-6.3.1.tar.xz"
SRC_URI[sha256sum] = "36694fefda51dffe4bdaa53505ae8998518e4c77aed5473a17ec33eea2af61c4"

