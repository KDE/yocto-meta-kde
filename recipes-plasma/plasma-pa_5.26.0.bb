# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.26.0/plasma-pa-5.26.0.tar.xz"
SRC_URI[sha256sum] = "ffb380e26cd4f5797d4bc724c1442ee35d9e13005957955e77b0cbed65965201"

