# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/5.27.4/kactivitymanagerd-5.27.4.tar.xz"
SRC_URI[sha256sum] = "d9e1fd492012127e20c8ae76cf6462c5690cf842f241ffa95f83c9bf6a91da72"

