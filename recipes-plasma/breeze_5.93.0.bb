# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.93.0/breeze-5.93.0.tar.xz"
SRC_URI[sha256sum] = "e5834fc95df4167735f903a7f17c02a6cd374515271fa804eaec964ea8e770c7"

