# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.27.0/plasma-mobile-5.27.0.tar.xz"
SRC_URI[sha256sum] = "bbce963dbeea85ec6451f80359ebbb3ce1491c98607efb117677d44e4d434691"

