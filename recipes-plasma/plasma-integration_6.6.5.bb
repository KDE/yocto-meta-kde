# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.6.5/plasma-integration-6.6.5.tar.xz"
SRC_URI[sha256sum] = "c28482dc8d3387b9a770fdc999dd13480b14714568395c8d86bd568b0181920a"

