# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.0.2/plasma-pa-6.0.2.tar.xz"
SRC_URI[sha256sum] = "998da8f7831e16004315bcb488d05d1d539713406e235155bdbfbb80d301e5ad"

