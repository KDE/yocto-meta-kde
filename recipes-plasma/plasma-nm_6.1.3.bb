# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.1.3/plasma-nm-6.1.3.tar.xz"
SRC_URI[sha256sum] = "5b5102ad7c808eb2fa4b036ef485d6586d2575f0789076dedefc1300ab90117c"

