# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.5.2/libkscreen-6.5.2.tar.xz"
SRC_URI[sha256sum] = "28099754348a7d3af74d79b443d7fde8e6a2b32c6e5491b520180d65d1e1ba61"

