# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.4/kgamma-6.3.4.tar.xz"
SRC_URI[sha256sum] = "fc3c61b1eea0807ff0471e4e89cb0efa0bf8b710933e159f794050982d9e4ddb"

