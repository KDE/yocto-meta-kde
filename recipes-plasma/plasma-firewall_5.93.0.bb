# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.93.0/plasma-firewall-5.93.0.tar.xz"
SRC_URI[sha256sum] = "aacfe186a97dd86e47ceb0ac0c774c38ffb895edc56044825c8e516811f264fb"

