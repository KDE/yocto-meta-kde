# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.0.0/kpipewire-6.0.0.tar.xz"
SRC_URI[sha256sum] = "dd585ee4de3b5bcdc10f36fe5df91966447ca716570d6b4ea15160db1f1d73bc"

