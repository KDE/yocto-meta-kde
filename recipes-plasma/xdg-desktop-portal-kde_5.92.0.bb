# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.92.0/xdg-desktop-portal-kde-5.92.0.tar.xz"
SRC_URI[sha256sum] = "cc013353880bff3f583d80427a18539bd76dac06a1359b36ba0546cf7e1205c8"

