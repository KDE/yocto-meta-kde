# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.1.3/plasma-activities-stats-6.1.3.tar.xz"
SRC_URI[sha256sum] = "fbe2235d911f6f712f5cc312d807999cc28d84a246d467781ad528956b89d669"

