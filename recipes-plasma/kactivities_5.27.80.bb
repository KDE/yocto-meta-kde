# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.27.80/kactivities-5.27.80.tar.xz"
SRC_URI[sha256sum] = "ef9f0051aabb8dc94deaa728a1f78678f1ccd11e4a96257b36a0438a3c0a41ba"

