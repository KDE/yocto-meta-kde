# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.6.5/kwallet-pam-6.6.5.tar.xz"
SRC_URI[sha256sum] = "5434a50f421867fc11190389bdebc43404b64cadcc7d87b1f08ff95ef199853e"

