# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.24.2/kwayland-integration-5.24.2.tar.xz"
SRC_URI[sha256sum] = "fb8cab0a35b6fee268243481707613f6cea9715cda96d124a0a508e3b2a1ba93"

