# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.1/powerdevil-6.3.1.tar.xz"
SRC_URI[sha256sum] = "bc6ded0bcbc217e83d11be82726a8a737e7e5f3041d7d17d3e40b3effb9e6391"

