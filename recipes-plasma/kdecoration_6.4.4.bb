# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.4.4/kdecoration-6.4.4.tar.xz"
SRC_URI[sha256sum] = "a02ac71ea8ee7ad6ab34578f1b50f32b91347a05a932cfc50b253729ccadee6f"

