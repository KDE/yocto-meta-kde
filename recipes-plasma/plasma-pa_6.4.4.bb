# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.4.4/plasma-pa-6.4.4.tar.xz"
SRC_URI[sha256sum] = "2e18bb284a1cba07e43b19ae7a192b574aaef94bc635d751d1eb21fcd569ca8a"

