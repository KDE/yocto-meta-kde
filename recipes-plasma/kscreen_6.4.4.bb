# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.4.4/kscreen-6.4.4.tar.xz"
SRC_URI[sha256sum] = "5890d24614ac6f93cc97964f9ca8b1bef95ec14508408dc87f3904d03b3af876"

