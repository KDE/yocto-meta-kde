# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.5.2/ksystemstats-6.5.2.tar.xz"
SRC_URI[sha256sum] = "d8c272a3242fe5d0937b9e3051b302335b30ebc3228e82d6549c12a4e5886fca"

