# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.0.2/kscreen-6.0.2.tar.xz"
SRC_URI[sha256sum] = "f1f56e3e5c70e5db75a5fc01b4f081edc811cbb368022bb70c4afabe255a0285"

