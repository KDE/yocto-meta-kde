# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.90.0/kglobalacceld-5.90.0.tar.xz"
SRC_URI[sha256sum] = "f14455962f0ea551758a1ab5abdfb9acb4fa3cf48c3122b451a95782f1aa60db"

