# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.4/krdp-6.2.4.tar.xz"
SRC_URI[sha256sum] = "f6229d1f7ccfce34d72e6565d8b4cbdc76ef35798794cd2ed2594f71ae8357bb"

