# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.1.3/kscreen-6.1.3.tar.xz"
SRC_URI[sha256sum] = "300919305a79f1d425141e8d368de3b0e35e8b4ff4c5fa40e4df07017ae6056b"

