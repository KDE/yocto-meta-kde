# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.92.0/polkit-kde-agent-1-5.92.0.tar.xz"
SRC_URI[sha256sum] = "1f36ee9b7ac2e766fa31182b6a2ac0e13f9aa8fbe5fceae7ab5aa39604b4f056"

