# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.24.5/kdecoration-5.24.5.tar.xz"
SRC_URI[sha256sum] = "273087d6345fd1f7bcefa570f56123cde4355832952dba6cb228fe04a6a152c2"

