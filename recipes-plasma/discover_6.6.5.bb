# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.6.5/discover-6.6.5.tar.xz"
SRC_URI[sha256sum] = "0d1471adf4b0b3bf92ac93225e2e4860493677f3fb9a02dbf44b193ae7c15357"

