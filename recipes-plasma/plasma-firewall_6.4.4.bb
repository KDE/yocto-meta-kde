# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.4.4/plasma-firewall-6.4.4.tar.xz"
SRC_URI[sha256sum] = "6b7b29043d8b0979da99f92ed7f9db9074b8da42d025c3ed497f2df862898842"

