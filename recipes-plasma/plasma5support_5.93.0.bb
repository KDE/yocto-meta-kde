# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.93.0/plasma5support-5.93.0.tar.xz"
SRC_URI[sha256sum] = "2dc3852ed193b79de96bec6affdacd56374698daac5a1c73a6da6cbcb926459e"

