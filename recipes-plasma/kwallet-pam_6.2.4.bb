# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.4/kwallet-pam-6.2.4.tar.xz"
SRC_URI[sha256sum] = "0b04a1c2d7ba4fdc20a0763727a5cd43622d2874523dd9fd833b912c1101d5e3"

