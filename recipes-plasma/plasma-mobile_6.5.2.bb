# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.5.2/plasma-mobile-6.5.2.tar.xz"
SRC_URI[sha256sum] = "6eca5d046ed46acdaedc64a1508c06e81cc9a205a0ca1609e88a94e9078b8067"

