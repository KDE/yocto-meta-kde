# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.2/milou-6.2.2.tar.xz"
SRC_URI[sha256sum] = "676864e514fec73aef346f140b57514a8610880fb250af7f8e7f73bfecebd4ed"

