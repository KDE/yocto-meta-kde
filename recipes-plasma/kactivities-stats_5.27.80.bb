# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.27.80/kactivities-stats-5.27.80.tar.xz"
SRC_URI[sha256sum] = "8708277ccdde9bdd976b7178ad240e361c6da378fd18989deaec952b6a53cd50"

