# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.24.2/plasma-nm-5.24.2.tar.xz"
SRC_URI[sha256sum] = "114ead32c90d521ae0504baee971da71a2c0f1a37d25bbf1868012ed030048cb"

