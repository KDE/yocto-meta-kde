# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.4/plasma-disks-6.2.4.tar.xz"
SRC_URI[sha256sum] = "732b27ce076fdffecb01b55184d4957e8592161764e579835d59e5cff5e7246a"

