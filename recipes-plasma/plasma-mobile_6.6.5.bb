# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.6.5/plasma-mobile-6.6.5.tar.xz"
SRC_URI[sha256sum] = "164380a6e1d75dc6fb072090caa3c4e5fb80bbb3f188d305bce767c90b9e4600"

