# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.27.0/breeze-5.27.0.tar.xz"
SRC_URI[sha256sum] = "8a5c57a4ea5d48a3f80a9eb06b7d7b27ed51bf1a765d9ea982e9eae626a0c83c"

