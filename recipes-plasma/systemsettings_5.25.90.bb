# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "git://anongit.kde.org/systemsettings;nobranch=1;protocol=https"
SRCREV = "dd7b7dd03531f9b08341aea247aedaf6729c6e7d"
S = "${WORKDIR}/git"
