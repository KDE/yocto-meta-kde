# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.24.2/plasma-mobile-5.24.2.tar.xz"
SRC_URI[sha256sum] = "8a5811275cec6021219fd341f6ec673e0038a0c8ac5e14f8a35869b3263c1322"

