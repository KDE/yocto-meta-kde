# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.1/plasma-nano-6.3.1.tar.xz"
SRC_URI[sha256sum] = "7276d3cc00b8761226e52ae3f4be4c6671e791c90bb5336431de3a774599835f"

