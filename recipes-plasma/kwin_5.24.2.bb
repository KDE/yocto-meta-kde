# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.24.2/kwin-5.24.2.tar.xz"
SRC_URI[sha256sum] = "2aabb59ef884cb2fb3f53b9577d651a1c39977a482bca93d6634ed3593054411"

