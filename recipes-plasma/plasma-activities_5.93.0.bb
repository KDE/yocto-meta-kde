# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.93.0/plasma-activities-5.93.0.tar.xz"
SRC_URI[sha256sum] = "dd42da97422d9931b66a7af05fabaee1d0846438c6bd62f7330bdbc0393eaa18"

