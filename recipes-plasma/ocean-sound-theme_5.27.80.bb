# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.27.80/ocean-sound-theme-5.27.80.tar.xz"
SRC_URI[sha256sum] = "72976b03840173900c902004bec364ed4feb175d9dd6f264798d28b888cb7ec3"

