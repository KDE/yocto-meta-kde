# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.92.0/plasma-welcome-5.92.0.tar.xz"
SRC_URI[sha256sum] = "013caf2aaddc11a7991b1d3f8f7d96b26adc00d006690d0db8858a1d8fe7daa4"

