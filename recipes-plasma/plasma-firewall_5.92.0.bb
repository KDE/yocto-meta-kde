# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.92.0/plasma-firewall-5.92.0.tar.xz"
SRC_URI[sha256sum] = "ed824abbd739c358293f223beb83397d104d674084c35ea12358cc0aca0b76b1"

