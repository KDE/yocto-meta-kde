# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.2/plasma-activities-stats-6.2.2.tar.xz"
SRC_URI[sha256sum] = "665feecfbf0473bedc6d77dd606f6b2771566726d5eae5e9f277488095fd10a5"

