# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.26.4/plasma-mobile-5.26.4.tar.xz"
SRC_URI[sha256sum] = "7d0819d6be0029dd43b6e5b64eb57816a69ef6c859cd6c2541be106b37da0697"

