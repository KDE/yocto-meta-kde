# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.0.0/xdg-desktop-portal-kde-6.0.0.tar.xz"
SRC_URI[sha256sum] = "c56ede3e5148df746839618b74b0ae38fb0fb6b10cd04a35c71bc92f8d57dd6a"

