# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.1.3/plasma-pa-6.1.3.tar.xz"
SRC_URI[sha256sum] = "4211b05f036d80e455a4c2a32184266017fe5dcd01fb7532760ac81d886aadf7"

