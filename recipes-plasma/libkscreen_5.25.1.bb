# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.25.1/libkscreen-5.25.1.tar.xz"
SRC_URI[sha256sum] = "af0887cf01b3954268d9a51791f78f485896e04d295f86e6d49fd955995a6dfd"

