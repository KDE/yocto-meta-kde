# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.0.2/plasma-desktop-6.0.2.tar.xz"
SRC_URI[sha256sum] = "0410e575e0f17caaaf16132aa3fccbba6431dd61ba746f3e2e202d294f54360a"

