# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.24.5/kwin-5.24.5.tar.xz"
SRC_URI[sha256sum] = "f35e15254cebeb8afc5eae1c694a603e04097fe3e7e0033a5f5fc255835eaf82"

