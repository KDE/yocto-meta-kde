# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.0.2/xdg-desktop-portal-kde-6.0.2.tar.xz"
SRC_URI[sha256sum] = "2d7e63fcb02bfa357f325d900387456aee0193ea414b2ede98b1a159b520e765"

