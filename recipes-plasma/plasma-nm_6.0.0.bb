# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.0.0/plasma-nm-6.0.0.tar.xz"
SRC_URI[sha256sum] = "52cf96738ceeafce65f183a3457325aeb5b1f18a4336ceede5a226556e6e9eb4"

