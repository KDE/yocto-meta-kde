require ${PN}.inc
SRCREV = "f1dd73e6715f6be23af092760c2c5e496697f2d5"
