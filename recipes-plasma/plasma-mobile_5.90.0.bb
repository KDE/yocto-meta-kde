# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.90.0/plasma-mobile-5.90.0.tar.xz"
SRC_URI[sha256sum] = "0ab436cec569ffc2593deab0a148cd3a9dd0d2fa91fa72052d0e47c13cd05558"

