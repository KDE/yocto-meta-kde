# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.90.0/qqc2-breeze-style-5.90.0.tar.xz"
SRC_URI[sha256sum] = "3b1c6ef8fc6a031b547068c4a033043454ba9b4f708cdc58157cfd8ea768bbed"

