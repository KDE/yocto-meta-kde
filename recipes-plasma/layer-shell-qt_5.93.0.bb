# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.93.0/layer-shell-qt-5.93.0.tar.xz"
SRC_URI[sha256sum] = "1b249f23af19a6c270a6bb6303457076166538e0f18c176f7a08c33b59249a40"

