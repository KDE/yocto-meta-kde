# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.1.4/breeze-6.1.4.tar.xz"
SRC_URI[sha256sum] = "226726df37b03cbcae15409fcb5dc3b69f560aee68541e401e2bd76080da01a5"

