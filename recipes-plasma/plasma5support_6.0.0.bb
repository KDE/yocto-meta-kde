# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.0.0/plasma5support-6.0.0.tar.xz"
SRC_URI[sha256sum] = "aa131487ff2c75c892ce8c52813b6e1fe2d6a49f52ed08f38700e22c0e99ebed"

