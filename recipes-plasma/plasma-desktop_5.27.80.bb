# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.27.80/plasma-desktop-5.27.80.tar.xz"
SRC_URI[sha256sum] = "67c2f5cf0046d0891d361cdc96d25b3783bd6ff961f255ffaa368a3687c86322"

