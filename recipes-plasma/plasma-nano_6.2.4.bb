# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.4/plasma-nano-6.2.4.tar.xz"
SRC_URI[sha256sum] = "5f6f4729093b98b7256400c90f69beaa0399fd09eadd148de010454d8a385a21"

