# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.1.3/libkscreen-6.1.3.tar.xz"
SRC_URI[sha256sum] = "9988f3736ec3d917f7b8bf1759c11c155a8ec57fcfd7876420e4bb9718b3b293"

