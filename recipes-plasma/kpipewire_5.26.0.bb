# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.26.0/kpipewire-5.26.0.tar.xz"
SRC_URI[sha256sum] = "7a09f3325b1be7868135d10fccc27466c5ed5dab75b6c71634940ac7f8b6beee"

