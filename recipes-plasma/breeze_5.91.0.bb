# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.91.0/breeze-5.91.0.tar.xz"
SRC_URI[sha256sum] = "3dcf63b7a0c3be9cace63b89758f11e30816e89f274a35bbeba5d0bce58218ca"

