# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.0/kwallet-pam-6.2.0.tar.xz"
SRC_URI[sha256sum] = "581dacb66e23aadb14568d03afc7e012ad909292277b192d8b68ec1cd427b9ed"

