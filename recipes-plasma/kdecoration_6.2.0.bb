# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.0/kdecoration-6.2.0.tar.xz"
SRC_URI[sha256sum] = "05d0d38ee55c922db135fd864e35c4742988a7b26516a341b824e9804960c919"

