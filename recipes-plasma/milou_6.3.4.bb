# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.4/milou-6.3.4.tar.xz"
SRC_URI[sha256sum] = "ae7bd7d22e66e588034fe21a73aa8b376d233e82f44470707b708c1771e3ff37"

