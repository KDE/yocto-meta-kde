# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "git://anongit.kde.org/kdecoration;nobranch=1;protocol=https"
SRCREV = "32ea05f4064cca5cbaeefae6fcf70f8a6268776d"
S = "${WORKDIR}/git"
