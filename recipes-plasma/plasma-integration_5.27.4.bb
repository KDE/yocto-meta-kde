# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/5.27.4/plasma-integration-5.27.4.tar.xz"
SRC_URI[sha256sum] = "9aa095f628d601d71283bb7b3274e2b8bfebd913c5804e3b371a5326f24b892e"

