# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.0.2/ocean-sound-theme-6.0.2.tar.xz"
SRC_URI[sha256sum] = "fa01e15b8a997e5dd34e7dea67a827129876582e6b0fdd4432352f16b6745577"

