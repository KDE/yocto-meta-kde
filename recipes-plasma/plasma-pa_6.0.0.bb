# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.0.0/plasma-pa-6.0.0.tar.xz"
SRC_URI[sha256sum] = "b49abb2bb74401b22cdae1d992101d764b483a18c60087c202f6e695145d022c"

