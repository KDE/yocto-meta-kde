# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.4/ksystemstats-6.3.4.tar.xz"
SRC_URI[sha256sum] = "00006a9370d03a1114c31a869c6c0676c4493aac3716138dd9aea898d0e85395"

