# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.0.0/libplasma-6.0.0.tar.xz"
SRC_URI[sha256sum] = "b1d8f4701a009dd18797cbf68f06bdc45a3e85a243b04190890b4b40440927d2"

