# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.26.0/plank-player-5.26.0.tar.xz"
SRC_URI[sha256sum] = "535cdf743de950131abb2fe0abf5f2b6ae36983a0f8e600f43922ebe16cc904b"

