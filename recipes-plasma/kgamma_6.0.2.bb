# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.0.2/kgamma-6.0.2.tar.xz"
SRC_URI[sha256sum] = "f80db1a6e89504040d51c6b14fa8ba06ac6787dc37c05bc41ec6cbcdb4639990"

