# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.4/powerdevil-6.3.4.tar.xz"
SRC_URI[sha256sum] = "bb8fb337fd214793396707730b22b8f822135296a6b2ac0c28d774096ab22b5e"

