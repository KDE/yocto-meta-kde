# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.25.1/plasma-mobile-5.25.1.tar.xz"
SRC_URI[sha256sum] = "9eed352e4549b3d0eb905f23463e07f226871e64811a07d04bef27f97d37af11"

