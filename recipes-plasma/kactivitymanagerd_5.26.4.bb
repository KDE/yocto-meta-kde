# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.26.4/kactivitymanagerd-5.26.4.tar.xz"
SRC_URI[sha256sum] = "8406805f1de0f5e6bb1fac08a9ff39fbb0cbbbe81ac0d9812f51b241816325cc"

