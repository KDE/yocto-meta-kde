# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.93.0/milou-5.93.0.tar.xz"
SRC_URI[sha256sum] = "152f7f8ff46440455ba619ad07deb9145b6de4d1a177da712ff6bd5658550da4"

