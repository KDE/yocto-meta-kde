# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.27.0/powerdevil-5.27.0.tar.xz"
SRC_URI[sha256sum] = "2f27b4fabe84e6cad22dfd49aabf075c166c7a4a475e92099d3f98d3f517b73d"

