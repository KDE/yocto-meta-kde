# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.90.0/plasma-nano-5.90.0.tar.xz"
SRC_URI[sha256sum] = "5e1da28ab7db8d40b80fee410d83f32ce79228533d1cce4b744711f47a524b7d"

