# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.25.1/plasma-nm-5.25.1.tar.xz"
SRC_URI[sha256sum] = "8973526de047563e7c93185b143606d897a644c694ec9d96f05b52114c233104"

