# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.0/krdp-6.2.0.tar.xz"
SRC_URI[sha256sum] = "be59f74c7baae2143bf5b2ff7722a392ed48e35dc42e4fd9b6fb6a81e9df4a9a"

