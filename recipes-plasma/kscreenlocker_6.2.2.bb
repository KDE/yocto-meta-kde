# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.2/kscreenlocker-6.2.2.tar.xz"
SRC_URI[sha256sum] = "1c8563e811bda80a6a129dd54897c35fb40345b9f5aa0e9cd99d1e28082a7699"

