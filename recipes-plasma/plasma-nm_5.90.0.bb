# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.90.0/plasma-nm-5.90.0.tar.xz"
SRC_URI[sha256sum] = "1b9a84eb31bb3ee661ba93e6d9f09b933253746f680aeb0474971e383460ac67"

