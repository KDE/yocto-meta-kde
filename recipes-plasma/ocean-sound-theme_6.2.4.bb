# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.4/ocean-sound-theme-6.2.4.tar.xz"
SRC_URI[sha256sum] = "7b5492abad8a75d242e788395cda054decfc85d0ff221bce05b924518f16300a"

