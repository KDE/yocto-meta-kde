# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.26.4/kscreen-5.26.4.tar.xz"
SRC_URI[sha256sum] = "d7dc48881feaa1b58edc2f9e7c07366bb6ce844a357b671e894180ba17f6c69c"

