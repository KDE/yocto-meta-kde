# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "git://anongit.kde.org/plasma-mobile;nobranch=1;protocol=https"
SRCREV = "70abb7823678720db970f22c5f5ce9410d67cb78"
S = "${WORKDIR}/git"
