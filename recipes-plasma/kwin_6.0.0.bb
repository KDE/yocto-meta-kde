# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.0.0/kwin-6.0.0.tar.xz"
SRC_URI[sha256sum] = "b1947c2b44de6190908462c81e8ac89ff9c7326a87641feb65e6ccd85262a4db"

