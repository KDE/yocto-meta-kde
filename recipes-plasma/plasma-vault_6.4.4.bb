# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.4.4/plasma-vault-6.4.4.tar.xz"
SRC_URI[sha256sum] = "2d843b1e37cb41b099c74142ad0d746942fdb447186d3e372ca6b7a3b051bc81"

