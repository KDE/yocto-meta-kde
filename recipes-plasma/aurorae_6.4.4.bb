# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.4.4/aurorae-6.4.4.tar.xz"
SRC_URI[sha256sum] = "b358a775772052e46b4978c63ad765996ca4600af0db1189260129fd91de6589"