# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.1/kdecoration-6.3.1.tar.xz"
SRC_URI[sha256sum] = "0adfb1bc8edd907a8b39d8908ddf4c6b2d16bc031d305b18c3be104192621d48"

