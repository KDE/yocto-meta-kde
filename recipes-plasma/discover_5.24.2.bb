# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.24.2/discover-5.24.2.tar.xz"
SRC_URI[sha256sum] = "24e99d349dc7992764aaa0ff311025fe116a79bfecce234c972bc21cf3d36052"

