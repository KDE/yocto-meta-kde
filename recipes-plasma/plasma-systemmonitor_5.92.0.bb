# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.92.0/plasma-systemmonitor-5.92.0.tar.xz"
SRC_URI[sha256sum] = "2a38ed3e2497cdd1d2832c8fe09a4663a2b85ec48beb2024be55562882f7af4c"

