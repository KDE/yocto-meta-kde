# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.6.5/kwayland-6.6.5.tar.xz"
SRC_URI[sha256sum] = "afbcd53ca8a5fb501038415f1473c3d11556eb56ed8f653ece03f77d799cad01"

