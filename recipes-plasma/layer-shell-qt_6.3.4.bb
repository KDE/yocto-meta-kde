# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.4/layer-shell-qt-6.3.4.tar.xz"
SRC_URI[sha256sum] = "f80c983f48d3abefd6684ce93fc67368ce207f2160734d4e113a418c69a26346"

