# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.24.2/layer-shell-qt-5.24.2.tar.xz"
SRC_URI[sha256sum] = "eefee96cf04cb1dbaede72b50354ddc7129915f1b88c340ff206724c29620f2c"

