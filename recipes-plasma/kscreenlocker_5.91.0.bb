# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.91.0/kscreenlocker-5.91.0.tar.xz"
SRC_URI[sha256sum] = "b92084283bf477d1fd1c9ce5de2356d02297c9e4f7e955ae267d16fa61e2e26b"

