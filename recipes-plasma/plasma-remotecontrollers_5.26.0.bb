# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.26.0/plasma-remotecontrollers-5.26.0.tar.xz"
SRC_URI[sha256sum] = "5725f61db8a7a2cb70dbd89dea10e01db4dae77b5af178b250b9e4d9b086953f"

