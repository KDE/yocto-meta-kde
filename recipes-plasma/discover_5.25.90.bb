# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "git://anongit.kde.org/discover;nobranch=1;protocol=https"
SRCREV = "2e5187dd507a423c6acbc5f2626d90b78f2b829d"
S = "${WORKDIR}/git"
