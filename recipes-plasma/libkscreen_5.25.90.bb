# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "git://anongit.kde.org/libkscreen;nobranch=1;protocol=https"
SRCREV = "aeff1f91a7a7587b90f8ce919c3ce5e7b14e4724"
S = "${WORKDIR}/git"
