# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.91.0/xdg-desktop-portal-kde-5.91.0.tar.xz"
SRC_URI[sha256sum] = "2cb103a78d0ee1486d64d4bb9a9d22128d4d73e3a94e989db208038bb0502125"

