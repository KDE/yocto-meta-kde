# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.0.2/kactivitymanagerd-6.0.2.tar.xz"
SRC_URI[sha256sum] = "e95ea29f8b6fb882bec51d9464912a74354ef5396bb3eab78830dae34aa4dfb0"

