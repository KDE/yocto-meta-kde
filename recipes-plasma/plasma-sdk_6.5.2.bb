# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.5.2/plasma-sdk-6.5.2.tar.xz"
SRC_URI[sha256sum] = "1205a8e7b9c1c50ecb2a30562c453a3207bd7bfae686e7ebcf20ab9193af223d"

