# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.2/ocean-sound-theme-6.2.2.tar.xz"
SRC_URI[sha256sum] = "6f19a1da39790449cc902a3cca952c2e5d93aa1f464438c7b5740352ddf597a5"

