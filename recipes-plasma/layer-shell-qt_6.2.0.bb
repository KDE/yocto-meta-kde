# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.0/layer-shell-qt-6.2.0.tar.xz"
SRC_URI[sha256sum] = "5390d178e7f6516d691edaa85fce9cbccfe060cea573abc650bb4066878eb2fe"

