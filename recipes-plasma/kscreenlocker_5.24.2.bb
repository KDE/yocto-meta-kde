# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.24.2/kscreenlocker-5.24.2.tar.xz"
SRC_URI[sha256sum] = "fcd9d5be26409819903b445d2ebe888ea2e7cba289304b80462e9d701e06d3e5"

