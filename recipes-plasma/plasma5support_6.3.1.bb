# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.1/plasma5support-6.3.1.tar.xz"
SRC_URI[sha256sum] = "666396f74e27dc1fb41aa82fcafd5ab33c878f1eb06ae793c45be22b70a6b961"

