# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.4/kwayland-6.2.4.tar.xz"
SRC_URI[sha256sum] = "f4fe69978f8e9b0c40058019782f13bfdd770cf545d9325a7b378826f0cd34ac"

