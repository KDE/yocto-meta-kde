# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.91.0/plasma-nm-5.91.0.tar.xz"
SRC_URI[sha256sum] = "d3db0fa7443d0981a603fbfa2a54d7951527af572992c227a7e8cab64e727d0d"

