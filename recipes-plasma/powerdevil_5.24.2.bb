# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.24.2/powerdevil-5.24.2.tar.xz"
SRC_URI[sha256sum] = "8c742e057f19e3852ed6403e7a3f86fa70a478ae0c6c30a492491a5b02b7cd8d"

