# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.90.0/bluedevil-5.90.0.tar.xz"
SRC_URI[sha256sum] = "ce109633d8f143bb8683447b74ad7dbc4360d590aeb4d7f1c7fa622a97d3dc6c"

