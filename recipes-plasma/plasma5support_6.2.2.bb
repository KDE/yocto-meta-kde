# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.2/plasma5support-6.2.2.tar.xz"
SRC_URI[sha256sum] = "8e26657768b5533bb1c7aeccd51658b47a61a66750438bf4b25ab96d63a8c730"

