# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.1.3/polkit-kde-agent-1-6.1.3.tar.xz"
SRC_URI[sha256sum] = "27b9da65056b1d07aca3b60641fc8ffa41e9dd03ffd1e138183f641613f2396f"

