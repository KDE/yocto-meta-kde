# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.0.2/kpipewire-6.0.2.tar.xz"
SRC_URI[sha256sum] = "00f986b6296032461a35871dbe8a12fc24c2f93b6239d3098c97b76dcbd46cc9"

