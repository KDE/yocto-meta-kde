# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.4/plasma-integration-6.2.4.tar.xz"
SRC_URI[sha256sum] = "8d3d9b022aef411a36aada564931aad4ec81df8b8ef6e3f4091e362522295cc7"

