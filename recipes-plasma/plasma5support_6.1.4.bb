# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.1.4/plasma5support-6.1.4.tar.xz"
SRC_URI[sha256sum] = "c99fd50d6496f7cf123d11e376790bcbcd6c80670af7e903ee0295ad42dd44d6"

