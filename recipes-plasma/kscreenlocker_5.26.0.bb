# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.26.0/kscreenlocker-5.26.0.tar.xz"
SRC_URI[sha256sum] = "e412b2cf65d69f80a866d0332397b494243068e270225f7c95de227b913ec73d"

