# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.92.0/bluedevil-5.92.0.tar.xz"
SRC_URI[sha256sum] = "6262b5e34ba28151652ade192827a5c54b26d985bb4542fdf53ccfab3c0b4c1b"

