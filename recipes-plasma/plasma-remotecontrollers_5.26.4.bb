# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.26.4/plasma-remotecontrollers-5.26.4.tar.xz"
SRC_URI[sha256sum] = "ba45c2122f317c45a1499449e18428e4087c953a0049da837ad491bc42e76cde"

