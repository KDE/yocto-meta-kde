# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.4/kdecoration-6.3.4.tar.xz"
SRC_URI[sha256sum] = "b9d049a9f5a6359856e66dbad0769b48189210ad7f8b3e009da2b4ae2813789a"

