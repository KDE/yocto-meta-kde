# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.22.5/breeze-5.22.5.tar.xz"
SRC_URI[sha256sum] = "e3fc4ca04cc0df694ab90fa4f9e8ca72512adae2c0320ce3f9702dddda029426"

