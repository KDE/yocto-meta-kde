# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.1/discover-6.3.1.tar.xz"
SRC_URI[sha256sum] = "44a8272a3fc912268d8b2461fed6e7193e0e66d27858ed5bbacd0b8e5319a718"

