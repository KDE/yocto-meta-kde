# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.1/plasma-sdk-6.3.1.tar.xz"
SRC_URI[sha256sum] = "955108ae3273e9a4bcef169d15b4025cf3fa0f0d4f6e07367e56d39647b4f709"

