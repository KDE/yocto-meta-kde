# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.92.0/ocean-sound-theme-5.92.0.tar.xz"
SRC_URI[sha256sum] = "8809fc04b539cac514b8aa9dbf1a91da1b828bfc60e6c12d401c355848d3f87f"

