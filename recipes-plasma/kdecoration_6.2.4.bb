# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.4/kdecoration-6.2.4.tar.xz"
SRC_URI[sha256sum] = "ac645b4d582d110258694a9e2ea2bf65fbbd4bd58e9de9f9354786397bc4f71a"

