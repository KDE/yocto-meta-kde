# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.91.0/plasma-integration-5.91.0.tar.xz"
SRC_URI[sha256sum] = "4aeba5b0eb693d5e406469e31774194792d64473886471b6d662b5f0e197e2f5"

