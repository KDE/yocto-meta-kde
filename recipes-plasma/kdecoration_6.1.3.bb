# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.1.3/kdecoration-6.1.3.tar.xz"
SRC_URI[sha256sum] = "15dd479f42eb4ab6752694d3129aa42164aec9954db5be04b7c3bb7c811b0dfb"

