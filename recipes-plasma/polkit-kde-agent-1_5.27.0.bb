# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.27.0/polkit-kde-agent-1-5.27.0.tar.xz"
SRC_URI[sha256sum] = "415f6fb58f5c934e07179dc94a7954508fdbf31f398527a0de98e6c451de3056"

