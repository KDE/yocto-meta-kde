# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.4.4/plasma-welcome-6.4.4.tar.xz"
SRC_URI[sha256sum] = "309e1b0d8d16491276b00657c24197c6200c2a3242c3f530a22307689b5d23b1"

