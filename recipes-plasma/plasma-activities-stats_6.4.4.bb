# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.4.4/plasma-activities-stats-6.4.4.tar.xz"
SRC_URI[sha256sum] = "dd43899617b0cc0e927a13bfb88146b761f7390c1fba568e2e4522f07f0f5901"

