# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.1.4/plasma-firewall-6.1.4.tar.xz"
SRC_URI[sha256sum] = "cb3f1c9aed0c659e0abca3c82041860ebf4009f0e73103eb565299b48a37bb64"

