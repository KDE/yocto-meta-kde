# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.5.2/knighttime-6.5.2.tar.xz"
SRC_URI[sha256sum] = "cffccfa45bb3014e5e027ddaa9f9549c8840847a0653942cec42114bc5cf9f0d"
