# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/5.27.4/polkit-kde-agent-1-5.27.4.tar.xz"
SRC_URI[sha256sum] = "6df939a1fe2ab3cc29a886d6037f9c39d21002940f35120a27e1e003568ca1e8"

