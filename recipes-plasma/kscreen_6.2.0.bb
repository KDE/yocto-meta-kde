# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.0/kscreen-6.2.0.tar.xz"
SRC_URI[sha256sum] = "0a51431ecf4fac486d3566f89e98c4d2e4bc9aa8d1a6b01e89e5dc60ff1fe5f2"

