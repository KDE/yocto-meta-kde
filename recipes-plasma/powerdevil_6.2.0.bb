# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.0/powerdevil-6.2.0.tar.xz"
SRC_URI[sha256sum] = "83c1fd55117757a8b4c4452a2f3047d8f42acc54f37ec045065a28d9264179c2"

