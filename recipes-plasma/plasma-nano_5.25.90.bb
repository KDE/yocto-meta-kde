# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "git://anongit.kde.org/plasma-nano;nobranch=1;protocol=https"
SRCREV = "054a21ffd60a6fdb30afee3099865c5d26ecf602"
S = "${WORKDIR}/git"
