# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.4/kglobalacceld-6.3.4.tar.xz"
SRC_URI[sha256sum] = "827d136e1912b62490264bfe6c03ce4e9d9d00773e72d377fce23f00bf70ead9"

