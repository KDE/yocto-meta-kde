# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.24.5/kwayland-integration-5.24.5.tar.xz"
SRC_URI[sha256sum] = "806a9607bb70f95b08ccad55f28eaf0a85adc1439afa2d2717b7c9d6c33022ec"

