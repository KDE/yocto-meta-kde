# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.2/plasma-activities-6.2.2.tar.xz"
SRC_URI[sha256sum] = "b1333bbce0b369701c99dd1fbf7435c14a674450c3d415bdce6c44c30a6d4ffb"

