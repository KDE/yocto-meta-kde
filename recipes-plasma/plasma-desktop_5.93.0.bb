# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.93.0/plasma-desktop-5.93.0.tar.xz"
SRC_URI[sha256sum] = "9daf810488efa23859d5b4d5e3fc600b2772d3d89b1dd042a0b1922b6aaa5594"

