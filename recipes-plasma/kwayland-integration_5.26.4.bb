# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.26.4/kwayland-integration-5.26.4.tar.xz"
SRC_URI[sha256sum] = "f019658d3e512557b2c5b464a58b0f5f9ae212339322528791ed4518f789e982"

