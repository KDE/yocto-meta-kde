# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.0/plasma-vault-6.2.0.tar.xz"
SRC_URI[sha256sum] = "c1f03d1b6b8fdf3918790f609664e80f8ba0f8ac49fee4e153cb8785e6dd2797"

