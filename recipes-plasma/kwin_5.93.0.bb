# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.93.0/kwin-5.93.0.tar.xz"
SRC_URI[sha256sum] = "4bbb7fae346b3695525a83db352f984660b53e09bc0196f1774d12bb95466f17"

