# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.1.4/plasma-nano-6.1.4.tar.xz"
SRC_URI[sha256sum] = "844e7d0a6b7819280df397ba99c44d42c27503937bff2a13a6ac43aeb8d888c2"

