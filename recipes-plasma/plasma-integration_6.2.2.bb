# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.2/plasma-integration-6.2.2.tar.xz"
SRC_URI[sha256sum] = "d32d054be6947627f05ddb574260a6a497686a7c93ec62d1c929168074bfb539"

