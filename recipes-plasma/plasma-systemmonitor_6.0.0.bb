# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.0.0/plasma-systemmonitor-6.0.0.tar.xz"
SRC_URI[sha256sum] = "589fd04f1fe0d96bfa297a4fe03eeb015c7b5f8399325bf233277dfe79e66f99"

