# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.2/kdecoration-6.2.2.tar.xz"
SRC_URI[sha256sum] = "b7f861a18e2af638a9c85f12e18306c0579f8bc1f09eca6c34335f58dd2c7b90"

