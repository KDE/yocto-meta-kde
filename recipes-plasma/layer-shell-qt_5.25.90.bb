# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "git://anongit.kde.org/layer-shell-qt;nobranch=1;protocol=https"
SRCREV = "92d8d496b095b798ce8dd307462db42ef6f1f310"
S = "${WORKDIR}/git"
