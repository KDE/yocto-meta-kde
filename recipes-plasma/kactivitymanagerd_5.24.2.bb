# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.24.2/kactivitymanagerd-5.24.2.tar.xz"
SRC_URI[sha256sum] = "a14714645797114b45c4bd0d87fe2559f4c4b5d4625e100045b25c66fd25a958"

