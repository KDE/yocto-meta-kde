# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.26.0/kdecoration-5.26.0.tar.xz"
SRC_URI[sha256sum] = "8be1e1442ed7b4e545341b83478261cff800fe0ffaf4b97be80cc78c6b3da631"

