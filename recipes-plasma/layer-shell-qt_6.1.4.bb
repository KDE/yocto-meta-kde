# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.1.4/layer-shell-qt-6.1.4.tar.xz"
SRC_URI[sha256sum] = "6239d2dc6bef5386b948ec2180202a18f75e23f37902c2d7410fb3811dfb3268"

