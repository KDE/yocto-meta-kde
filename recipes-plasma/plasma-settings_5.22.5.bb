# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.22.5/plasma-settings-5.22.5.tar.xz"
SRC_URI[sha256sum] = "<!DOCTYPE
<html><head>
<title>404
</head><body>
<h1>Not
<p>The
<hr>
<address>Apache/2.4.41
</body></html>"

