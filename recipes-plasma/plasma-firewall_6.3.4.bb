# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.4/plasma-firewall-6.3.4.tar.xz"
SRC_URI[sha256sum] = "9e91db09487b2ed55ec3164c67402535175ec480ac6489d9c8f23e00a6fbc547"

