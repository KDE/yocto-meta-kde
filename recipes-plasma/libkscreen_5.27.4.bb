# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/5.27.4/libkscreen-5.27.4.tar.xz"
SRC_URI[sha256sum] = "a89dfb5e8c40958a41c264f9b26ec4c39b386c2e416aa29a17967a22c107fa7e"

