# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.27.0/kdecoration-5.27.0.tar.xz"
SRC_URI[sha256sum] = "4ec94df56f2e6c98486d0328e2ee080255a806336915c42f7ab260befd4c7c13"

