# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.2/plasma-pa-6.2.2.tar.xz"
SRC_URI[sha256sum] = "2fc8316d5d4851c7f01cf10213403d3e77cb7a4a04584bc0dc637971e9d22654"

