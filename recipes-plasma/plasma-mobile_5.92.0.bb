# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.92.0/plasma-mobile-5.92.0.tar.xz"
SRC_URI[sha256sum] = "2260e779ec274a8147d63021369532bc277fdcee7c65b86d75804b48996764e1"

