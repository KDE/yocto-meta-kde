# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.5.2/libplasma-6.5.2.tar.xz"
SRC_URI[sha256sum] = "194fcfd972b7c0882e88528603d8aef69aa0a5ef199730bf5b1e33022f21e6e1"

