# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.1.4/kde-cli-tools-6.1.4.tar.xz"
SRC_URI[sha256sum] = "d6d84afc71bab6bec45ca87333b261694920cc2246345b363cc469edadae1ae2"

