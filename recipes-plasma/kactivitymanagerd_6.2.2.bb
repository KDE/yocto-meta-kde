# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.2/kactivitymanagerd-6.2.2.tar.xz"
SRC_URI[sha256sum] = "f250a0428c1f901e14c3759adbe11f1b2708c088966037acb203165d400a2ce1"

