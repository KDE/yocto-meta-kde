# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.91.0/bluedevil-5.91.0.tar.xz"
SRC_URI[sha256sum] = "87654012f2952920de2a3e36d5048812076dac41d802521ba973c282e7cb4d4b"

