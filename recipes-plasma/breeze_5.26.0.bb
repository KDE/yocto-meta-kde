# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.26.0/breeze-5.26.0.tar.xz"
SRC_URI[sha256sum] = "11ed27c9049a0ba1f0a0e506244872972e5cfa961bf9f528fca19ecd5738437c"

