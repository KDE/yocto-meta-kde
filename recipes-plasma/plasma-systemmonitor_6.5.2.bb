# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.5.2/plasma-systemmonitor-6.5.2.tar.xz"
SRC_URI[sha256sum] = "0a3329bbd7b1f4cba7434d347895c7ee1814bb0643d1200bbfe0ff1cf8bcca21"

