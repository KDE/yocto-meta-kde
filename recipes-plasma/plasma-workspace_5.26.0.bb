# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.26.0/plasma-workspace-5.26.0.tar.xz"
SRC_URI[sha256sum] = "841fd34bc55fa18c4d4373ba33b3ad6464f8f43a4db698aa8c83791f185556b2"

