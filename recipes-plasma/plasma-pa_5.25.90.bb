# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "git://anongit.kde.org/plasma-pa;nobranch=1;protocol=https"
SRCREV = "0a071826d557b3ae3651c901f3f20c46e203c680"
S = "${WORKDIR}/git"
