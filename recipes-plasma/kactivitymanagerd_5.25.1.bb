# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.25.1/kactivitymanagerd-5.25.1.tar.xz"
SRC_URI[sha256sum] = "60726c7f4176cc99adca5f924f7d465f7a983e274e7de9b52853417413f04bca"

