# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.24.2/plasma-systemmonitor-5.24.2.tar.xz"
SRC_URI[sha256sum] = "16902047b659cbe7e3452e527699aa8891546323a54efc60d0fdcfac8fe0ccd4"

