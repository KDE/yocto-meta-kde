# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.26.0/systemsettings-5.26.0.tar.xz"
SRC_URI[sha256sum] = "bf2f10c0b51454d567d94f912e7d7cb6b01a87f935a70399643da4962b884fcc"

