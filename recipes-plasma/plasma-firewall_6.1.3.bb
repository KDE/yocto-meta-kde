# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.1.3/plasma-firewall-6.1.3.tar.xz"
SRC_URI[sha256sum] = "f2a0a74e01969630cd21a0f03697a924ea33d6da2f92b08d900d28b97843cf93"

