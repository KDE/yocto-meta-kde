# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.1/qqc2-breeze-style-6.3.1.tar.xz"
SRC_URI[sha256sum] = "29e914a9fb140552046bf814129a8615c18cfb4f15da7fbbe1b19e6f88bdc25a"

