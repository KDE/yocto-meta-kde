# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.2/breeze-6.2.2.tar.xz"
SRC_URI[sha256sum] = "9f07568d543513b984870817d3dda252cf1524f11617bd3138a71d2bf658965c"

