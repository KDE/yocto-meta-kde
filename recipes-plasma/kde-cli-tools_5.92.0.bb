# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.92.0/kde-cli-tools-5.92.0.tar.xz"
SRC_URI[sha256sum] = "063fd56e92ddcadd04bbbeb8e54e511731d4fbf77374128dfd147b3f277718e7"

