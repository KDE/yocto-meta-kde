# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.0.0/plasma-integration-6.0.0.tar.xz"
SRC_URI[sha256sum] = "133ff66eca6363b798b5152e96e370400213e5a2bc28bd633d8b691406b02c41"

