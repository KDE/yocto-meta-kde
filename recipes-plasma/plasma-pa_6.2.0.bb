# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.0/plasma-pa-6.2.0.tar.xz"
SRC_URI[sha256sum] = "8a6493177d9d823f747fe917acc3bc859c61c4fe9d3add799ab7f19434d99920"

