# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.4/plasma-sdk-6.2.4.tar.xz"
SRC_URI[sha256sum] = "576f6aa751d9d2cf66cdf09562ce86ed02cbbf73e5ae5ccbd06e01f8163b8878"

