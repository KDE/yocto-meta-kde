# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.4/kscreen-6.2.4.tar.xz"
SRC_URI[sha256sum] = "3f660c98e698b53a94eab75f55dd56e2aff2dc7ae34c8be69875466599e7b002"

