# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/5.27.4/plasma-nano-5.27.4.tar.xz"
SRC_URI[sha256sum] = "ea8e1e62a3b633fb14dbf125bc53f747fabf89c33dd99557167de2a18b5ce0fc"

