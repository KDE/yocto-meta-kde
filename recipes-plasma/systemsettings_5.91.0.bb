# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.91.0/systemsettings-5.91.0.tar.xz"
SRC_URI[sha256sum] = "f2e3546f975b184ee2958249c83271159004ef5f92a968a5fa169956baeff333"

