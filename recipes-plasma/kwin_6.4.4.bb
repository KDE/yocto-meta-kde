# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.4.4/kwin-6.4.4.tar.xz"
SRC_URI[sha256sum] = "b0742a12133b052519cb5af09132114ebf4d96b44e320015cc0d2d0bf055dae6"

