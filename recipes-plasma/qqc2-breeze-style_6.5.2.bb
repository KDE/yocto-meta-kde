# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.5.2/qqc2-breeze-style-6.5.2.tar.xz"
SRC_URI[sha256sum] = "d5483dab67c578230c7e78c9fa54bb900d9e19356f915058e482a84d91956c81"

