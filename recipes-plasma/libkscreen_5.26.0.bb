# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.26.0/libkscreen-5.26.0.tar.xz"
SRC_URI[sha256sum] = "4e9aeb63a89834a2bf46e56f67db44aadcdcc3c9a7852dc3162abc6397115e24"

