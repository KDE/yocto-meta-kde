# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.1/plasma-workspace-6.3.1.tar.xz"
SRC_URI[sha256sum] = "617d2a3230304ada2edcac7d8759d366ddaf99b59bd8853bce471cf44b9341c5"

