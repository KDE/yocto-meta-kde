# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.0.0/discover-6.0.0.tar.xz"
SRC_URI[sha256sum] = "7ba825fe4779a495ffed4692b50e71170e20233db9901ecbe1528edc3ab3dfb0"

