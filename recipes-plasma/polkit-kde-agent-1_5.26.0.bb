# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.26.0/polkit-kde-agent-1-5.26.0.tar.xz"
SRC_URI[sha256sum] = "aa43650accd6bacab633e95b9b9c9d607dd22f265ac15ef7c0eda0e713c488bb"

