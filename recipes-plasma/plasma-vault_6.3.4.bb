# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.4/plasma-vault-6.3.4.tar.xz"
SRC_URI[sha256sum] = "de77af74e09c9539edcf6308ee45e028309905bea08e24f5ff985977e9f86c62"

