# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.26.4/discover-5.26.4.tar.xz"
SRC_URI[sha256sum] = "8cb73da1cc70a04370923775cd4ede92156cbfc7b520d041a32b600fce2988c2"

