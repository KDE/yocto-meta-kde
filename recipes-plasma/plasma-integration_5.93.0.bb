# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.93.0/plasma-integration-5.93.0.tar.xz"
SRC_URI[sha256sum] = "bed1dd0d7ce71ce991cc0e0c7494958968a4e18adaeff80aaf65c888c94ea3ef"

