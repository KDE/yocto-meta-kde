# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.27.0/aura-browser-5.27.0.tar.xz"
SRC_URI[sha256sum] = "5f95e43eabadbd49d013b57f0bbe11dd0c4924688bd4b1fef138fbf5f6c68753"

