# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.1.4/kwallet-pam-6.1.4.tar.xz"
SRC_URI[sha256sum] = "7324b13e0327cfb73fdb4ade8948cad17b854e02241dfa9c17cbab858f2f2e36"
