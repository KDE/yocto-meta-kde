# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.5.2/plasma-disks-6.5.2.tar.xz"
SRC_URI[sha256sum] = "9ac9853f39d9d4da72b7fb0fd858a64af992b96a6bc25e81b5511988ddf51d7b"

