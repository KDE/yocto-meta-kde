# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.92.0/qqc2-breeze-style-5.92.0.tar.xz"
SRC_URI[sha256sum] = "d1f99b9fd5da2f0e792c22727b4d5ddd4c8fd369f170316a26144ab07b8e3636"

