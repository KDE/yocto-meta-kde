# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.27.0/plasma-workspace-5.27.0.tar.xz"
SRC_URI[sha256sum] = "01244ed2df75960192cf810a263410a7b2c9b34c3c237b14429d028ba10b073b"

