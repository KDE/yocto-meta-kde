# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.4/libkscreen-6.2.4.tar.xz"
SRC_URI[sha256sum] = "3cc06d5c561ab4dbedbc548a4655119e861c4ac29e565ff5846273f0c76e9cb4"

