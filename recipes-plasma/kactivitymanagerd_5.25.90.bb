# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "git://anongit.kde.org/kactivitymanagerd;nobranch=1;protocol=https"
SRCREV = "d524ebc942828af1d2305239f94a89f923cb18ed"
S = "${WORKDIR}/git"
