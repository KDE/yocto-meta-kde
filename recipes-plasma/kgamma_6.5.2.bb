# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.5.2/kgamma-6.5.2.tar.xz"
SRC_URI[sha256sum] = "538353ffcdfb7e6d66e16b1a3fafffa478b293c7d57656ca71016f2aeb782eee"

