# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/5.27.4/kdecoration-5.27.4.tar.xz"
SRC_URI[sha256sum] = "415f22a21073dcc8024eba45a5a8f19b83d3af8335404d3a253554b1a483fa6e"

