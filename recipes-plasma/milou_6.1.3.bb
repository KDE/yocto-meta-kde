# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.1.3/milou-6.1.3.tar.xz"
SRC_URI[sha256sum] = "de698adc56d297f336b756dcc1e311d55b84c3433c22d1b36ded7ec59e09eb88"

