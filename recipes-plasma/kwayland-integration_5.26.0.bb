# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.26.0/kwayland-integration-5.26.0.tar.xz"
SRC_URI[sha256sum] = "ee1041d400424b7f4116d3395906a3bda752e547f7d3639c589d919fe4ada440"

