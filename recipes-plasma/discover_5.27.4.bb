# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/5.27.4/discover-5.27.4.tar.xz"
SRC_URI[sha256sum] = "dc9f66d0ad4cf11a5033593976cae0b9969bc148babbb2ad72a3527b1003f966"

