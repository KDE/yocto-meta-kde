# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "git://anongit.kde.org/polkit-kde-agent-1;nobranch=1;protocol=https"
SRCREV = "b14d048e3ea9ccb53548098a65d5da4c89a4819e"
S = "${WORKDIR}/git"
