# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.1.3/plasma5support-6.1.3.tar.xz"
SRC_URI[sha256sum] = "37d875f77f8f0d463b409cc31e296c581dbe73e75ac014db3ae11372a51ff76d"

