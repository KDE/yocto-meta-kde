# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.4.4/kactivitymanagerd-6.4.4.tar.xz"
SRC_URI[sha256sum] = "38f24d9529810495db1a2d0f102a89885d22813f131fb6453b79d898bfcbe2a4"

