# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.24.2/kwayland-server-5.24.2.tar.xz"
SRC_URI[sha256sum] = "147b0312fe456ca5018da641fb5758d94d55eca136d075729d322829634ee247"

