# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.93.0/plasma-nm-5.93.0.tar.xz"
SRC_URI[sha256sum] = "f81bd0318f688cda3767206beeb814151e18d846cfea844fba70f0e7634fafe5"

