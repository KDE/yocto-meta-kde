# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.93.0/plasma-activities-stats-5.93.0.tar.xz"
SRC_URI[sha256sum] = "c8566ed38fbf5877fc8f60f9e36c6d8c5e2717ee71f0f32bec146c455a2b4596"

