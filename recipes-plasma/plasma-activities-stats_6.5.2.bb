# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.5.2/plasma-activities-stats-6.5.2.tar.xz"
SRC_URI[sha256sum] = "b9a65b164ed7a3012118e0891670ca5e8287b2cb8f42f562dc7f649852f49000"

