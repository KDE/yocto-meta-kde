# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.4/plasma-activities-stats-6.3.4.tar.xz"
SRC_URI[sha256sum] = "014bd3eb983dc8e10ff52ed02f8d490562b9d0d623918e9270d9d84aa5b28b4d"

