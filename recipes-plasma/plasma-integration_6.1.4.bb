# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.1.4/plasma-integration-6.1.4.tar.xz"
SRC_URI[sha256sum] = "08a12823fd78e7be04e23f1dd1f5ee6eb1535cab561237d6efd4b0d032dcaa74"

