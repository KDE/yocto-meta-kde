# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.4.4/plasma5support-6.4.4.tar.xz"
SRC_URI[sha256sum] = "066c0456149bacad6dfd99eb36783fb61f1918df91b9d70ff4aeac56e3d43bf5"

