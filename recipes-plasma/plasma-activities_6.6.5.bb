# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.6.5/plasma-activities-6.6.5.tar.xz"
SRC_URI[sha256sum] = "54d06a22a5765aa1e92834885d02abc7ce1bf8d6bda9533bb3472d4fef575562"

