# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "git://anongit.kde.org/plasma-bigscreen;nobranch=1;protocol=https"
SRCREV = "9f9ea69a3a53ba12e7792e908c47960ceaf3606e"
S = "${WORKDIR}/git"
