# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.26.0/kwin-5.26.0.tar.xz"
SRC_URI[sha256sum] = "3a9f4769c08c568397fbf956019c00de3086a18a263f2a1a2738fd4b344029fd"

