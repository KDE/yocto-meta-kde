# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/5.27.4/plasma-bigscreen-5.27.4.tar.xz"
SRC_URI[sha256sum] = "97a9a17822a4d722f08cb2db8fe9ac3b7b48ad4b47b09032496336afc67c4da2"

