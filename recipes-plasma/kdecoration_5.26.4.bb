# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.26.4/kdecoration-5.26.4.tar.xz"
SRC_URI[sha256sum] = "88fc3b01796e06784a9008882195b33bc0c076c42dd7c81c63b1078e8d47285d"

