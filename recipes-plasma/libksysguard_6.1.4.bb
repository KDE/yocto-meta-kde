# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.1.4/libksysguard-6.1.4.tar.xz"
SRC_URI[sha256sum] = "d2a7aebc9571ce81b4ca79095b74a0d91829c249303d22462038203a4c56c5b1"

