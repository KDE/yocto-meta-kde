# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.1.4/kscreenlocker-6.1.4.tar.xz"
SRC_URI[sha256sum] = "1dc70ae8de365d3ec41f8f5a33b46099add5a650c23469f7a73f72c85b3aeb73"

