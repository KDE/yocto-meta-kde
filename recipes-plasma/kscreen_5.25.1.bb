# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.25.1/kscreen-5.25.1.tar.xz"
SRC_URI[sha256sum] = "4a417c55d9c97e617484b699553a68f7acd86b5843149b72993c00a09652d4b5"

