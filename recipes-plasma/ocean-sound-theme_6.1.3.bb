# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.1.3/ocean-sound-theme-6.1.3.tar.xz"
SRC_URI[sha256sum] = "06f96b114871602b2b5d2d7cd9061be501e12789ffbf80424149a83774259a18"

