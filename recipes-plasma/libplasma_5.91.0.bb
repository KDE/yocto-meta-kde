# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.91.0/libplasma-5.91.0.tar.xz"
SRC_URI[sha256sum] = "c5bed16526b19edbba4a5aeab1ecb4aa2a3744f2cfcad0874685546fab56c047"

