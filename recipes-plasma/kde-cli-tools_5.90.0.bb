# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.90.0/kde-cli-tools-5.90.0.tar.xz"
SRC_URI[sha256sum] = "6a7e11387d97c8e4905fcbc37d8fc7226c631d06124ad2e134002ce087b9c22b"

