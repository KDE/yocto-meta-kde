# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.22.5/milou-5.22.5.tar.xz"
SRC_URI[sha256sum] = "f7c22b46d9a5081206f78e9964f515055876b7b4e9e6075d5fcc50b85c783fb4"

