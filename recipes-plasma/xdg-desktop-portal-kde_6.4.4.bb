# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.4.4/xdg-desktop-portal-kde-6.4.4.tar.xz"
SRC_URI[sha256sum] = "dcd501b11a785c0b0f0b30bf1d09ba120d83885276841c47feed51d77e1440a5"

