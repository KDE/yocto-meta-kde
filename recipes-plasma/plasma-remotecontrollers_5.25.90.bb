# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "git://anongit.kde.org/plasma-remotecontrollers;nobranch=1;protocol=https"
SRCREV = "0cddb61d9f784dba8a94bc328bd29c1c62a6d14c"
S = "${WORKDIR}/git"
