# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "git://anongit.kde.org/plasma-nm;nobranch=1;protocol=https"
SRCREV = "f6ea386b2c14d17cfc96f6407af0d1ae3322bce9"
S = "${WORKDIR}/git"
