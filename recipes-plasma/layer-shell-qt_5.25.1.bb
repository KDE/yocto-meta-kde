# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.25.1/layer-shell-qt-5.25.1.tar.xz"
SRC_URI[sha256sum] = "aca4b73393015a6d96c124ac87126e28d4ffdbad8bf5d601616622f0836f0152"

