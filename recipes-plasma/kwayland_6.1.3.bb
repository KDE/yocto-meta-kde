# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.1.3/kwayland-6.1.3.tar.xz"
SRC_URI[sha256sum] = "69674a6656d042d96a3a13ab1d7076ab0551c40bc387ad33d693a4d077ea9abc"

