# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.0/plasma-welcome-6.2.0.tar.xz"
SRC_URI[sha256sum] = "6782406d5643745953de82b1b1f58a44a6f854c2d7e0d675d037e63377f552d5"

