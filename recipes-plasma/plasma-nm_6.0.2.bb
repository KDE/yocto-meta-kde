# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.0.2/plasma-nm-6.0.2.tar.xz"
SRC_URI[sha256sum] = "42e6f31b3ec6de51ee3cefdb52299e655cdd20a5c8b4d7880429184e2f92d0c6"

