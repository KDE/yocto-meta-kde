# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.24.5/plasma-nm-5.24.5.tar.xz"
SRC_URI[sha256sum] = "ae1026cf7d2fb60f862ac9b985da4f7001f54267602062e461d0849f1d2fb429"

