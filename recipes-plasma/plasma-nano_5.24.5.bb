# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.24.5/plasma-nano-5.24.5.tar.xz"
SRC_URI[sha256sum] = "230873425584d68424fd23e95daf31f89a2bb08696c015503191991bdec7bb7f"

