# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.93.0/libksysguard-5.93.0.tar.xz"
SRC_URI[sha256sum] = "f3120fb53128877ff32fe6a11d7d8077c023faac024371b09f5faa1d08bf1369"

