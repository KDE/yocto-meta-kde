# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.4/plasma-nano-6.3.4.tar.xz"
SRC_URI[sha256sum] = "18ea488cae6feb91bd326c5db293c3c99785fb7f583bf9cb0f7dcd1bfbe0da20"

