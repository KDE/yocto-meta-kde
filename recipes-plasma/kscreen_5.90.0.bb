# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.90.0/kscreen-5.90.0.tar.xz"
SRC_URI[sha256sum] = "31d61d108d0c400f2cece4650a77153a8fae9d761d482badd5b281686b29424e"

