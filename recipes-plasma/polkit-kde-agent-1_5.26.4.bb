# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.26.4/polkit-kde-agent-1-5.26.4.tar.xz"
SRC_URI[sha256sum] = "5a05c610776c869c2c8bc8b800574e85340edeb8c86b0530d59e512b49a207ec"

