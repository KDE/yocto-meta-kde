# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.93.0/powerdevil-5.93.0.tar.xz"
SRC_URI[sha256sum] = "638c9f2329a0b4a2859edcf3bdc1c4358d6d8dbf3c1043d7b44d87661ad2ebf6"

