# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "git://anongit.kde.org/plasma-integration;nobranch=1;protocol=https"
SRCREV = "ddc3eea7fb0d2ff6a9f15e20f3aaeab29e593438"
S = "${WORKDIR}/git"
