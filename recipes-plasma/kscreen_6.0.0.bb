# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.0.0/kscreen-6.0.0.tar.xz"
SRC_URI[sha256sum] = "f97c0457630bce0d90fdbc0f6c45f1e2b21a60144bd182d8b41f58939bfd7346"

