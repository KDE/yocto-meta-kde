# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.4/plasma-workspace-6.3.4.tar.xz"
SRC_URI[sha256sum] = "85d99dd0d8a33758997af033d24c45ee399152efd2c8b7de0bd3a34fd1cdd155"

