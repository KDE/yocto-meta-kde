# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.1.4/kscreen-6.1.4.tar.xz"
SRC_URI[sha256sum] = "99fe64edb097fc8285ec2bd3222d02fcb5c9560d29fcbe41f7f4b898b1e331af"

