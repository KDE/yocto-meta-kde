# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.91.0/powerdevil-5.91.0.tar.xz"
SRC_URI[sha256sum] = "984a09323eefc3773f2d56417ccefd365ea1dc48ad4859780d9085e35973ea9b"

