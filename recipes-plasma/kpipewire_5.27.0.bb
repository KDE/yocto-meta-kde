# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/5.27.0/kpipewire-5.27.0.tar.xz"
SRC_URI[sha256sum] = "0018fee05e03e2eb5c0ed2a6417d20a5ae2e33216fd2745fb77f15014c881756"

