# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.1/plasma-mobile-6.3.1.tar.xz"
SRC_URI[sha256sum] = "ea957813da444944042013719f28c66030237106897793a192ad3b49a0b968df"

