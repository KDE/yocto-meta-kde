# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.4/plasma-systemmonitor-6.3.4.tar.xz"
SRC_URI[sha256sum] = "99d7c42912681172e304958fb1d330cecc6ce95db8a0336953ff2b4d0c65ac5d"

