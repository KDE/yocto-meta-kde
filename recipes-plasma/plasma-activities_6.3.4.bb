# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.4/plasma-activities-6.3.4.tar.xz"
SRC_URI[sha256sum] = "670a5718438f0c915da6b125a34f8b46293b22f9edbc4bd6f0cce370f3d0dd05"

