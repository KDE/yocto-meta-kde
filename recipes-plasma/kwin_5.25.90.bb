# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "git://anongit.kde.org/kwin;nobranch=1;protocol=https"
SRCREV = "b409f5f52af01eff433108ab844d548a2824692a"
S = "${WORKDIR}/git"
