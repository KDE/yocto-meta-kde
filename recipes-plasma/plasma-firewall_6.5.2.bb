# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.5.2/plasma-firewall-6.5.2.tar.xz"
SRC_URI[sha256sum] = "da13244defa7b4ab6efb59072109a8d3327a7ec851d15e47a3bc1aba155a41df"

