# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.2/xdg-desktop-portal-kde-6.2.2.tar.xz"
SRC_URI[sha256sum] = "669f9c1446a9b73490c3ed142895b22738eda9887eecbf62ccd9d6d1050a3dd3"

