# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.2/libksysguard-6.2.2.tar.xz"
SRC_URI[sha256sum] = "eea8947ce5ab8f82fd9352464c49418bd97460921b61497e9118d0656af0fd9f"

