# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.24.2/systemsettings-5.24.2.tar.xz"
SRC_URI[sha256sum] = "b31e3bbd0ed6c69718341e7290f8a8888e972ca3c1eae10f2a5da912b17d2e5c"

