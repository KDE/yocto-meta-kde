# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.4.4/plasma-mobile-6.4.4.tar.xz"
SRC_URI[sha256sum] = "8481ca63a93575fa443248be0b86e0536f4452538479cddfa6cf958e0f9112f1"

