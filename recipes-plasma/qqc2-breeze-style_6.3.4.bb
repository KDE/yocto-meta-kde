# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.4/qqc2-breeze-style-6.3.4.tar.xz"
SRC_URI[sha256sum] = "ee209948de91e24e4195afd0d594672dd805a73444531916c2ad8f99f551f9c6"

