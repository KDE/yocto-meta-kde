# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.0.2/libksysguard-6.0.2.tar.xz"
SRC_URI[sha256sum] = "969faebdf997ca097e94dd877df27ec5bff496714f66789fe62cd4557bec6dd3"

