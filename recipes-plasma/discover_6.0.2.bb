# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.0.2/discover-6.0.2.tar.xz"
SRC_URI[sha256sum] = "8c3b964188ee37249aa1bd4acd52967d8803bc40b75f3b7718593c1cd6ccf4f0"

