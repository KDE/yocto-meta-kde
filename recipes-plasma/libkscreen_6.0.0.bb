# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.0.0/libkscreen-6.0.0.tar.xz"
SRC_URI[sha256sum] = "c42a7290c899fc8b887890a7b03efd720b476d7ac6fc91c64e6f03dadff09b44"

