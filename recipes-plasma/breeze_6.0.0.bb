# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.0.0/breeze-6.0.0.tar.xz"
SRC_URI[sha256sum] = "bc72a16b116b7beabf1b4e9a451019f9048e7be6b05ac73a4627f25b2c2059ea"

