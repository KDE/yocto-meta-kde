# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.1/plasma-activities-stats-6.3.1.tar.xz"
SRC_URI[sha256sum] = "c801901c62144f30ecd7e4f7b17bc8e05a45ab1cb3d808c8d0a1d569f012b5a6"

