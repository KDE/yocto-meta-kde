# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/5.27.4/systemsettings-5.27.4.tar.xz"
SRC_URI[sha256sum] = "6d39a082e9532f0f41295afd20c3c4d7075d8ecd829529537e201a6a76664d07"

