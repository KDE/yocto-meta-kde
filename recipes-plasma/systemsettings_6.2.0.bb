# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.0/systemsettings-6.2.0.tar.xz"
SRC_URI[sha256sum] = "6b4675edd4717f7ca88d17700696c38873ff46b3f9063ecfa7cc207eb04ebae0"

