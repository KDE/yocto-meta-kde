# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.91.0/plasma5support-5.91.0.tar.xz"
SRC_URI[sha256sum] = "a6dfcf26027424791275cddfccf53af459e70a0298387b3fc7a6ee3963dcbf36"

