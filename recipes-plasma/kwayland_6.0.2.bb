# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.0.2/kwayland-6.0.2.tar.xz"
SRC_URI[sha256sum] = "bdc2e78f575ab5a8d5a2bd3108a3cc30467a334958b3cffdac04839db835d833"

