# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.6.5/bluedevil-6.6.5.tar.xz"
SRC_URI[sha256sum] = "4396447a83b5dab5c4867690824180c36f4f3922107463722fed42202d8a45ff"

