# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.93.0/kpipewire-5.93.0.tar.xz"
SRC_URI[sha256sum] = "334a5c2c9b743557af81d53f4c9b0632a993fe2dc552609d176e015569164f41"

