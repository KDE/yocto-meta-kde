# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/5.27.4/xdg-desktop-portal-kde-5.27.4.tar.xz"
SRC_URI[sha256sum] = "d38e4dfe0cc878353ab87ecb486071ebbd22154f3544bf3216e7041c01ac17c5"

