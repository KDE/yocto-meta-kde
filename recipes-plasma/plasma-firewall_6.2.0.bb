# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.0/plasma-firewall-6.2.0.tar.xz"
SRC_URI[sha256sum] = "59fd0579a6c9913f97466ebbe562b00c27b590d9c3874c239c8a51fe61903e65"

