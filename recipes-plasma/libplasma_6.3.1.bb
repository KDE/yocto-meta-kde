# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.1/libplasma-6.3.1.tar.xz"
SRC_URI[sha256sum] = "6455b4aff5d83f1586b4bba97ffaae9b3881b6b02182ec1535f872f7f08f460c"

