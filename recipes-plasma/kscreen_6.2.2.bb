# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.2/kscreen-6.2.2.tar.xz"
SRC_URI[sha256sum] = "a200ab840c78f7e5e4202f4630f612effec44d62ed91d9baa7a05ec6785845f0"

