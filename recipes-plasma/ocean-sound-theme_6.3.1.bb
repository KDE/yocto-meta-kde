# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.1/ocean-sound-theme-6.3.1.tar.xz"
SRC_URI[sha256sum] = "170b2371bc4a9a1263f778714a2ccbf47af7c63b4de975b29b07b036ddfcedc1"

