# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.1/kde-cli-tools-6.3.1.tar.xz"
SRC_URI[sha256sum] = "32f8d495b6ca4b098d2285e947211c0195ee553b187de792ca2ad4a0b03cba90"

