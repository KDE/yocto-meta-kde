# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.91.0/milou-5.91.0.tar.xz"
SRC_URI[sha256sum] = "a283ea7c3de45ca6b681e0750c1e6232ca0a5c3c8217128e886330d82aae2c00"

