# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.26.4/layer-shell-qt-5.26.4.tar.xz"
SRC_URI[sha256sum] = "ebd088a6c5d0bf5c8adf4b06c7c0d8f55f4c3c332bf930b06b7b389ae47260c1"

