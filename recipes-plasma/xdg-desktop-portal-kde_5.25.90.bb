# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "git://anongit.kde.org/xdg-desktop-portal-kde;nobranch=1;protocol=https"
SRCREV = "ea3a5d6ab7a29b4bccc530614918eaecc92a9315"
S = "${WORKDIR}/git"
