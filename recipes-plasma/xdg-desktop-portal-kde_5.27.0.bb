# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.27.0/xdg-desktop-portal-kde-5.27.0.tar.xz"
SRC_URI[sha256sum] = "70d50c45d87a7b993d637d374bd953c41dde29ed57b85c401de69e7d08d72e19"

