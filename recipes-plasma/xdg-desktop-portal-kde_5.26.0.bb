# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.26.0/xdg-desktop-portal-kde-5.26.0.tar.xz"
SRC_URI[sha256sum] = "9e9a673fc9055f4c63d4f4b00264385f978be15f58868c1ef6cf4751bb472f9e"

