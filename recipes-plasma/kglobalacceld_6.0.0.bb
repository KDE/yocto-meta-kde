# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.0.0/kglobalacceld-6.0.0.tar.xz"
SRC_URI[sha256sum] = "aa7eb34f3dfafdc2f475bb20ed6a8563a2e9fbfb06470890e127dc9054f945aa"

