# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.92.0/kwayland-5.92.0.tar.xz"
SRC_URI[sha256sum] = "d9abb060473127a0d0fbe6a6ab2e12260ae68e72fe6179717cb820a9f9ae273a"

