# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.0/plasma5support-6.2.0.tar.xz"
SRC_URI[sha256sum] = "46eb4f5d94077c46c24b494bbae2e5749b5b5f7cc1db6ef2923b8112ae6ae58d"

