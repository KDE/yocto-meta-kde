# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.91.0/kactivitymanagerd-5.91.0.tar.xz"
SRC_URI[sha256sum] = "6e7992c6169de3e642296248c9c1aea805a063ac5ff29e629cb36263e7c11ba7"

