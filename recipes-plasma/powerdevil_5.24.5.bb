# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.24.5/powerdevil-5.24.5.tar.xz"
SRC_URI[sha256sum] = "964ca1b876005595c361add1eab5fa80c8d63da12c1201bdcd234914c6cc23f3"

