# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.24.2/libksysguard-5.24.2.tar.xz"
SRC_URI[sha256sum] = "13983f626906db864eda20bfa2e994ccbe4ddc534af7a052675b3475b7e9472f"

