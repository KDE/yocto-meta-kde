# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.4/krdp-6.3.4.tar.xz"
SRC_URI[sha256sum] = "84bcf0668bda172e3aaff010b7bac2bd10df289a1f458abcdb5dd4e6c5258cbc"

