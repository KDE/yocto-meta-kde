# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.1.3/kscreenlocker-6.1.3.tar.xz"
SRC_URI[sha256sum] = "c29c0f09864111a933cba754e0db2f954fe515d13c390496770adc9eec0ce653"

