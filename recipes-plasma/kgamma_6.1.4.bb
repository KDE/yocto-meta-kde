# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.1.4/kgamma-6.1.4.tar.xz"
SRC_URI[sha256sum] = "bd20882a6676a76a06206b424368ab4aef7279871ea5461bbd8522dac1718a7c"

