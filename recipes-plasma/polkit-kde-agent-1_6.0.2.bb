# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.0.2/polkit-kde-agent-1-6.0.2.tar.xz"
SRC_URI[sha256sum] = "3e2dec7f7f2f4342c7cf8cdc64972be573509a83564ffc1af7e0d91bf57462bd"

