# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.2/kde-cli-tools-6.2.2.tar.xz"
SRC_URI[sha256sum] = "8164a9b7ea24d64c5939a50ad03d613241317ea656b52bbb00afd653f144306c"

