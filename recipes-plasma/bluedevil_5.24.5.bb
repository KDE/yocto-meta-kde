# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.24.5/bluedevil-5.24.5.tar.xz"
SRC_URI[sha256sum] = "c96999c1400804e8bddc8b9801c4951f82daca83110e036bdc9c89faaeb31efa"

