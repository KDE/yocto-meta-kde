# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.26.0/layer-shell-qt-5.26.0.tar.xz"
SRC_URI[sha256sum] = "de043d147e2d900227870c73881015895b4b37d971a5075ffeaa021026cfb61e"

