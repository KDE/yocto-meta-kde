# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.26.4/kpipewire-5.26.4.tar.xz"
SRC_URI[sha256sum] = "46274e57d863fabe5e344c0e29f48d1eb27cc7318c923d33056d025870a5f634"

