# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.4/plasma-activities-6.2.4.tar.xz"
SRC_URI[sha256sum] = "7c975d2421e6792e8c3cca5f22611dac55f44e1ec8648df97712f00cbb907ccb"

