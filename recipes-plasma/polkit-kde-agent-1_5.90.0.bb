# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.90.0/polkit-kde-agent-1-5.90.0.tar.xz"
SRC_URI[sha256sum] = "b33d69f92d68f9a065729ea6a9624a9a71e5497c1ea551a5b1cc68464c09d1e8"

