# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.92.0/discover-5.92.0.tar.xz"
SRC_URI[sha256sum] = "195122bd63049a142d60360590c2a575f8b38b4f9abc8402638b92aec2f72a18"

