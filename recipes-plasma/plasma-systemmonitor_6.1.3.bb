# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.1.3/plasma-systemmonitor-6.1.3.tar.xz"
SRC_URI[sha256sum] = "ff82e2fd7a844d3d2c652537a783e009f3c42869776714520d439815fcb2d8f9"

