# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.26.4/plasma-nano-5.26.4.tar.xz"
SRC_URI[sha256sum] = "ba87b074211538ef4b757b838cb1dc39353bb46eaa055765e8538e5741925d96"

