# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.0.2/plasma-nano-6.0.2.tar.xz"
SRC_URI[sha256sum] = "c43c428f93a3c703a47de3834aeafa7ed8c711a9b0132c2cd7b669fedfed729c"

