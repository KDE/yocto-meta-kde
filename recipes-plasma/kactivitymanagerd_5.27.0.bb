# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.27.0/kactivitymanagerd-5.27.0.tar.xz"
SRC_URI[sha256sum] = "560fb9be7077031e9d28644b728b4aacfa6b98be100e6367cbc3d0a7098d680a"

