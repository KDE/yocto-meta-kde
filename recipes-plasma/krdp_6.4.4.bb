# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.4.4/krdp-6.4.4.tar.xz"
SRC_URI[sha256sum] = "228d8630ff2e14fa899ad611d1865399f9e6128538f9df91273ab3968f7cec84"

