# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.90.0/plasma-activities-stats-5.90.0.tar.xz"
SRC_URI[sha256sum] = "42c7ad00fa952ba3948fc49e135516afcd7e039467cc216df643766055349e3a"

