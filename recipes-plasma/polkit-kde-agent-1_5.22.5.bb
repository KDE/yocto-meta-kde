# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.22.5/polkit-kde-agent-1-5.22.5.tar.xz"
SRC_URI[sha256sum] = "60e3ea544b2b609351961fe7f299b79c9f8ff89b911b63490fa0d3afd5222ba8"

