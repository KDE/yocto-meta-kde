# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.6.5/kglobalacceld-6.6.5.tar.xz"
SRC_URI[sha256sum] = "33c95fb7b3cddab5766e0cb063a721af5f796b2841114183a6246e0ef557edc3"

