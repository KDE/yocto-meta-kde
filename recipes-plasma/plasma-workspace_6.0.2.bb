# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.0.2/plasma-workspace-6.0.2.tar.xz"
SRC_URI[sha256sum] = "9cceb4e2bce045970fc177bf2847ffae58bd397806b8ccf44da5820a3bd600ce"

