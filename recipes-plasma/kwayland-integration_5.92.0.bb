# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.92.0/kwayland-integration-5.92.0.tar.xz"
SRC_URI[sha256sum] = "33b0ccd6716707cccdfc20595478774acf38d70aa693d3ea9d15c3a09b06e43a"

