# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.0/kscreenlocker-6.2.0.tar.xz"
SRC_URI[sha256sum] = "9bf404ffb0d7d7dc196b2588ae5f473fd85eeade7cb2f56400e39106c1147f17"

