# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.4/kde-cli-tools-6.3.4.tar.xz"
SRC_URI[sha256sum] = "8a00f5ec0ab2e2706ecb5ed26c0b7df90524fd469cd157698476e3a54a385522"

