# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.27.0/plasma-nm-5.27.0.tar.xz"
SRC_URI[sha256sum] = "8e34e66e81a4ac3ac8e2fb65cd9d294f4735f3a4aaf0f22841fef2690fc7fb5c"

