# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/5.27.4/kwayland-integration-5.27.4.tar.xz"
SRC_URI[sha256sum] = "f74a856a93e0bd91ad7c34905603c2ed74df1dc85e687354d9d588274026fe08"

