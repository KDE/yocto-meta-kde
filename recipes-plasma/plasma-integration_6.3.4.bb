# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.4/plasma-integration-6.3.4.tar.xz"
SRC_URI[sha256sum] = "cb8aa01e40653b6e0f71ad367cb95756b1777ea027122cb661c2ffdfd41091b7"

