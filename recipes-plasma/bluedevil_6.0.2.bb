# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.0.2/bluedevil-6.0.2.tar.xz"
SRC_URI[sha256sum] = "815e0e110ef39503ec05a46bd75fbd225552b9e85050a9b43f2d8a7803e1db60"

