# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.90.0/kscreenlocker-5.90.0.tar.xz"
SRC_URI[sha256sum] = "d10b64225cb17a264d2f7135ec64e1f06ce781434d2aab9e06171646b078c14a"

