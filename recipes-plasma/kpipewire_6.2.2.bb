# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.2/kpipewire-6.2.2.tar.xz"
SRC_URI[sha256sum] = "1229db97447cc07e62e4a1cc3c7c5e5b4edd8c172ee1b922fd27b58ac3784255"

