# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.1.4/kactivitymanagerd-6.1.4.tar.xz"
SRC_URI[sha256sum] = "989652c371ba811c3eb9b161b30687f46caffc3bc1fac917554c79514a9870c0"

