# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.26.0/kde-cli-tools-5.26.0.tar.xz"
SRC_URI[sha256sum] = "14202b5f8d5751f44d1ad96f0d24971c5c2f6ed100e2dc4f855829debee89670"

