# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.26.4/plasma-nm-5.26.4.tar.xz"
SRC_URI[sha256sum] = "1e9ef4ba5d37a9cd938c947380ce84acaeefffaae3d71b1c0b803a3986633df4"

