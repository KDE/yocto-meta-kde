# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.92.0/plasma-nano-5.92.0.tar.xz"
SRC_URI[sha256sum] = "9d536700df8f1660a40609812144b9980fb423d846e42a77dd60dd8bf2e2049a"

