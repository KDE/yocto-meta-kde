# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.1/plasma-firewall-6.3.1.tar.xz"
SRC_URI[sha256sum] = "ad227126c686089f9369dccc9427c0a0bcc40fa6c86c8dfcae679d84c63f233d"

