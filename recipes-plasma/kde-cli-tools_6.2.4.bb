# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.4/kde-cli-tools-6.2.4.tar.xz"
SRC_URI[sha256sum] = "117acba7d68006e0299fd68128b6fe54859e920e0e38a4f394998ab88111d9e7"

