# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.22.5/kscreen-5.22.5.tar.xz"
SRC_URI[sha256sum] = "6bfab1f10532599e16d1112e794626b105b4c80c41659665ffdf710bc29d1e60"

