# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.22.5/plasma-systemmonitor-5.22.5.tar.xz"
SRC_URI[sha256sum] = "dd9eaaeba11da2d9640873882ed4aa573c2b3fc2f5640783965992ceda1647a3"

