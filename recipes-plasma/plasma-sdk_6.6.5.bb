# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.6.5/plasma-sdk-6.6.5.tar.xz"
SRC_URI[sha256sum] = "ed540a8bda1a633881fca41f7dfe96ae17c9a654b71374a79e86cf547efcc959"

