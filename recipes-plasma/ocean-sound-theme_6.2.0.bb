# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.0/ocean-sound-theme-6.2.0.tar.xz"
SRC_URI[sha256sum] = "9dfbb716795b8c605d40992a0b39eb2a7cb9c3ec7d3f52913991018872543383"

