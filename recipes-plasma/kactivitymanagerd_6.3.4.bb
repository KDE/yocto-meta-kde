# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.4/kactivitymanagerd-6.3.4.tar.xz"
SRC_URI[sha256sum] = "4f50b5e57f83b28a888393186348477644877b889c300651e0e06dd77ee97502"

