# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.2/kwayland-6.2.2.tar.xz"
SRC_URI[sha256sum] = "ec534c5a6057265feaac12b6e173cc823f8cbaa65c98e50ab067cafb01830f05"

