# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.0/discover-6.2.0.tar.xz"
SRC_URI[sha256sum] = "40ffcab43962034ed4c8848baa4e354f48ff3dd8b94d329dc3deec38606495ff"

