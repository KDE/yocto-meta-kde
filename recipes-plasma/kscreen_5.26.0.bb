# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.26.0/kscreen-5.26.0.tar.xz"
SRC_URI[sha256sum] = "26e4295fac92e142b25e97908866860506bf4f52ef5e1d114c788c1506c3c52b"

