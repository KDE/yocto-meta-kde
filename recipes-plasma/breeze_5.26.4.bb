# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.26.4/breeze-5.26.4.tar.xz"
SRC_URI[sha256sum] = "6c093f48b49228a01d7be1563c6f05e98c1ecf0c71c466cf45edb4328a58006b"

