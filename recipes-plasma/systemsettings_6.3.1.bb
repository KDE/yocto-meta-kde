# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.1/systemsettings-6.3.1.tar.xz"
SRC_URI[sha256sum] = "0d0325a27b8833925b486c7c0ed7ca56f71f94d1fca2ee8afd8c87ec126f6b6f"

