# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.1.4/plasma-sdk-6.1.4.tar.xz"
SRC_URI[sha256sum] = "f0664a22ee99f415050bc2ed583d8a137214acb282930cb0f1e0d9b17ed2734a"
