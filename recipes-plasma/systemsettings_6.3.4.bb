# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.4/systemsettings-6.3.4.tar.xz"
SRC_URI[sha256sum] = "234ca17d05a5d09c1570e1d935fd03da2dd4ce53c5b7545ba436a56ad4b9ef83"

