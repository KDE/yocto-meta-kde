# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.0.2/breeze-6.0.2.tar.xz"
SRC_URI[sha256sum] = "4c67f5a59a9a37c96754552c7a5076d29ea7864ac50fa9766719764ed94fb4cc"

