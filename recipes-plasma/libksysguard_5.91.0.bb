# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.91.0/libksysguard-5.91.0.tar.xz"
SRC_URI[sha256sum] = "184070fefba2b18c370f0651c4440ea15a5610f7ee691b9f1cb796e8c6ea9013"

