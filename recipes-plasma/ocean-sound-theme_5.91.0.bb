# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.91.0/ocean-sound-theme-5.91.0.tar.xz"
SRC_URI[sha256sum] = "548457a368968e218d0404135e273b83f514445faaa288e7919d56da880e4025"

