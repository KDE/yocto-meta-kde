# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.24.5/polkit-kde-agent-1-5.24.5.tar.xz"
SRC_URI[sha256sum] = "89a61cc4f2dee58dd420317b0732a67f954cd22f03d47c4bb33d9c6a5361e870"

