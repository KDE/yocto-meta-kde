# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.1.3/kactivitymanagerd-6.1.3.tar.xz"
SRC_URI[sha256sum] = "40c498e65afe7039c464cfbaa442a9e3a56140cbd45b63b6957267260c537460"

