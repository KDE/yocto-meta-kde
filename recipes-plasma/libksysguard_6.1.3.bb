# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.1.3/libksysguard-6.1.3.tar.xz"
SRC_URI[sha256sum] = "6ae86313aa63d33d5fbe7f8b914802ce6c6ef75dee8c009fe1ae4d5f5b5bffa4"

