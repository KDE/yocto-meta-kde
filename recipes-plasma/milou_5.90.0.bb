# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.90.0/milou-5.90.0.tar.xz"
SRC_URI[sha256sum] = "cab188bde4a611d6398a6c9a98dc39a23b978ba313087c9b08d66cfd5c52e334"

