# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.91.0/plasma-pa-5.91.0.tar.xz"
SRC_URI[sha256sum] = "dca67ccdd1b8937c3cfca959616924b0d3c3f7b0596c84aa4cb721d2c72001be"

