# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.6.5/plasma-nano-6.6.5.tar.xz"
SRC_URI[sha256sum] = "e5143dedbbcd0d75bbde4b442780cc7f3792470ee782fc455fcb15190a579658"

