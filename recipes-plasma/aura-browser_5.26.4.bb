# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.26.4/aura-browser-5.26.4.tar.xz"
SRC_URI[sha256sum] = "daa51b684c221c91ea038115969111a6cf308e1ecffb2ede845ace0ed616fbbe"

