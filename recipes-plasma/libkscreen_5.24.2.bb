# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.24.2/libkscreen-5.24.2.tar.xz"
SRC_URI[sha256sum] = "a64c2263a0de898a4a0e73f85949b4d3868aef87aa221d597e8c16f412103b04"

