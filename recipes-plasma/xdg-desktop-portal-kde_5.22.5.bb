# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.22.5/xdg-desktop-portal-kde-5.22.5.tar.xz"
SRC_URI[sha256sum] = "861d71bd0146c5c67d5c1774506fd201ed5be1e706d5cc9a05be0428136ca601"

