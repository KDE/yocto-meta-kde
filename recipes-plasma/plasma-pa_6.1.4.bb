# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.1.4/plasma-pa-6.1.4.tar.xz"
SRC_URI[sha256sum] = "344bd460a8f6a9ff44ebf713f6459fb1dc5c3ab1c3eda5acf66fbc91f3e4734d"

