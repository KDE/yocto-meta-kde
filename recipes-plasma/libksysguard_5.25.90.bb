# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "git://anongit.kde.org/libksysguard;nobranch=1;protocol=https"
SRCREV = "e1e07d0726a365ef609c33494cbadb5cc26ef1b1"
S = "${WORKDIR}/git"
