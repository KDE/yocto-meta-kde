# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.4/powerdevil-6.2.4.tar.xz"
SRC_URI[sha256sum] = "17c440d7d596be07797f604985c4b25f9297128aafd6f11b88a4a9afe20bddaf"

