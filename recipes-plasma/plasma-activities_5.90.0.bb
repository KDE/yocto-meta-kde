# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.90.0/plasma-activities-5.90.0.tar.xz"
SRC_URI[sha256sum] = "20e4a29ca6376f28f74c700febf3d8ea0cd4b0d91fe731080fafa43908f8d1a2"

