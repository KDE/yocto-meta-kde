# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.4/kwayland-6.3.4.tar.xz"
SRC_URI[sha256sum] = "a90848d5238ab75e706c96a535acbef5110441e92ffc9fc94336c69a1edf6835"

