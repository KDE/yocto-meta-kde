# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.24.5/kactivitymanagerd-5.24.5.tar.xz"
SRC_URI[sha256sum] = "ea9276b022264b3b92a1307be83ca0030a5f12270d9ad5ff1e92f82c1928cd48"

