# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.0/kpipewire-6.2.0.tar.xz"
SRC_URI[sha256sum] = "72c07e6c6608b6c5eaa2460d975bf9047489651fb05de5e5b540876529f425b0"

