# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.24.2/xdg-desktop-portal-kde-5.24.2.tar.xz"
SRC_URI[sha256sum] = "0b703bb222726ea1fe2161728f027d381862a03d0d693806f481a1249f78fda3"

