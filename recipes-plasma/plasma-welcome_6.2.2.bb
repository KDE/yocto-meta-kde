# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.2/plasma-welcome-6.2.2.tar.xz"
SRC_URI[sha256sum] = "0d60f383658b05f82063b603231424e8e93c383d1be1372f019049946e405f91"

