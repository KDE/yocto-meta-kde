# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.1.3/plasma-welcome-6.1.3.tar.xz"
SRC_URI[sha256sum] = "416d3568deae29f44135d754dfba39f912b2435b494ded20e8ff9f3b9034b41c"

