# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.26.0/discover-5.26.0.tar.xz"
SRC_URI[sha256sum] = "df4b5f32a38ee3ea254837e4b6a66c0b9874927bfa86fe3f0e6df9e00b4ff170"

