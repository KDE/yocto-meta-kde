# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.24.2/breeze-5.24.2.tar.xz"
SRC_URI[sha256sum] = "5fee72b7bc88fe8d97b575f46de62037ac2f898c7a5ff024e62f1082d60984b9"

