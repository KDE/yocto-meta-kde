# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.25.1/kscreenlocker-5.25.1.tar.xz"
SRC_URI[sha256sum] = "a7567a8266b5120db8b319e96e29f6cb2fb27490f33b83998f227f28834214ae"

