# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.4/kwin-6.2.4.tar.xz"
SRC_URI[sha256sum] = "d4b78ebdc9432cb1e224621ac43cfb81b92dbcee034afe90bbeb5b22f218f321"

