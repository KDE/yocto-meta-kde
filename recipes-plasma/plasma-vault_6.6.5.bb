# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.6.5/plasma-vault-6.6.5.tar.xz"
SRC_URI[sha256sum] = "68a4e3cd160db15646882c5a40aec3aa3eb709701a3b4274d02b6393feabb268"

