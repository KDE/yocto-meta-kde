# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.1.4/kglobalacceld-6.1.4.tar.xz"
SRC_URI[sha256sum] = "6cb493bea3316ac916e87f5602299a97f1f02fdc01669a52ea25223a6085ada8"

