# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.26.4/kscreenlocker-5.26.4.tar.xz"
SRC_URI[sha256sum] = "a126eb7085fff1aa9982c4567faaca16e930a28e60d021ef69d73276c956e857"

