# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.27.80/plasma-framework-5.27.80.tar.xz"
SRC_URI[sha256sum] = "48e6d43bf293e33394b71f6c2057056934733d4d62e4039b3e091b793b6f0e7d"

