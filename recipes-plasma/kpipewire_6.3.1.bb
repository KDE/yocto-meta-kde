# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.1/kpipewire-6.3.1.tar.xz"
SRC_URI[sha256sum] = "2f42394cc40183c193c4515a1572cc83a4e150c750c0e39024d4a857f783d8da"

