# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.0.0/kwayland-6.0.0.tar.xz"
SRC_URI[sha256sum] = "00312094681966a4cf692288398047a24136f1bce132307304d0dffa1cf9ed79"

