# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.26.0/plasma-systemmonitor-5.26.0.tar.xz"
SRC_URI[sha256sum] = "41bf6b7e24d39b4e429a2dbf4389d86229f15997ad680f4405557e10291647fa"

