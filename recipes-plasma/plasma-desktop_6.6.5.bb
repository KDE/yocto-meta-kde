# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.6.5/plasma-desktop-6.6.5.tar.xz"
SRC_URI[sha256sum] = "1d758dffcc42e1d3fbbfea0500009d3dc795cf1313b93b574da83624177085f3"

