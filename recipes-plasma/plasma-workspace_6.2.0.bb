# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.0/plasma-workspace-6.2.0.tar.xz"
SRC_URI[sha256sum] = "2d4268cbae757631be57d69d34fc02c8d0204762515370c9679ecb2aa2afdf33"

