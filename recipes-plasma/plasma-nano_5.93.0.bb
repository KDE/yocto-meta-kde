# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.93.0/plasma-nano-5.93.0.tar.xz"
SRC_URI[sha256sum] = "34ccc85800956877c0b767f0d9a1937f7086462fa9c6dd24253f1b3eae32bc64"

