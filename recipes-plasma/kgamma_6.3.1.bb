# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.1/kgamma-6.3.1.tar.xz"
SRC_URI[sha256sum] = "4dc8fa5af3f400d5761d1333c9c79b66a2507601764c4de64aa7bc5e139c0c74"

