# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.27.0/kscreenlocker-5.27.0.tar.xz"
SRC_URI[sha256sum] = "397690ed31738549d3aaf1dd026a5fbd50feddd97566ad121532db6920a67c77"

