# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.92.0/systemsettings-5.92.0.tar.xz"
SRC_URI[sha256sum] = "813e189ab51084fa848bc1eeb15ceae698bd758c2b4665804a6100ed082d328e"

