# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.26.4/milou-5.26.4.tar.xz"
SRC_URI[sha256sum] = "00bc5c80bf0160e1ea43e2c621de90a5ca69bbebfa288964e021387980009d69"

