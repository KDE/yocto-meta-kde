# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.4/milou-6.2.4.tar.xz"
SRC_URI[sha256sum] = "b47a635904a77aa82fb02d96a0261000cc95da01d07498ea9f29d4c0743775f9"

