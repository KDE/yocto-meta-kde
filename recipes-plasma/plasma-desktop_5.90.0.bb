# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.90.0/plasma-desktop-5.90.0.tar.xz"
SRC_URI[sha256sum] = "803a21727597b2cfa9a6b80f11f40c6da838b030915e02873091674da2ae3f39"

