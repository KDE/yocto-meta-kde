# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.0.2/plasma-vault-6.0.2.tar.xz"
SRC_URI[sha256sum] = "5f806a46b640b7ea8ad9f18d939ca13434cecbe29eaf463493ee6f9c197c1c90"

