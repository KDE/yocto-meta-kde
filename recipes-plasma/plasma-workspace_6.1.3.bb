# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.1.3/plasma-workspace-6.1.3.tar.xz"
SRC_URI[sha256sum] = "799cdefb52856db7273bb49a205c6e057165e77baec484c7c622ee6882c4d5ca"

