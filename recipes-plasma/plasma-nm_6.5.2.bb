# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.5.2/plasma-nm-6.5.2.tar.xz"
SRC_URI[sha256sum] = "e7c3e9c389b8e6d8deac5d9e3a103be092111fcfe8dec5718356a07fba787fdc"

