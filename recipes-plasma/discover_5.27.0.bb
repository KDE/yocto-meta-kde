# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.27.0/discover-5.27.0.tar.xz"
SRC_URI[sha256sum] = "bf45bcbb06ac20417653bbf7976f6983a95ac8f8a50756224f2cb8eece874961"

