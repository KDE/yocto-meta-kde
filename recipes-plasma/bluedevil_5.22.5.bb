# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.22.5/bluedevil-5.22.5.tar.xz"
SRC_URI[sha256sum] = "a21094de5445e662786ab7ce7274106f9bd8a25233de363eea73403ce62fcc05"

