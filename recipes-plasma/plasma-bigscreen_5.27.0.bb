# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.27.0/plasma-bigscreen-5.27.0.tar.xz"
SRC_URI[sha256sum] = "af7bb311431f5e0d33e6a3a9fe69c14aef34f0592e714dc7e67462a759a35f30"

