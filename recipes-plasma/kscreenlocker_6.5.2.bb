# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.5.2/kscreenlocker-6.5.2.tar.xz"
SRC_URI[sha256sum] = "d009894a88964a0c44370ddd5a83b7a95e64f6aad2f47b26fef7cc881d0d04b6"

