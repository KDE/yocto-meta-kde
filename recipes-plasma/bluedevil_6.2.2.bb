# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.2/bluedevil-6.2.2.tar.xz"
SRC_URI[sha256sum] = "d2a32f804ead2e04cc25dc90f67c25c158512c50d434ba7eb6f96a974cc4c849"

