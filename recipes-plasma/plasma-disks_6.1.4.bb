# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.1.4/plasma-disks-6.1.4.tar.xz"
SRC_URI[sha256sum] = "795f6bdaba2fe979d5836479111fc3d6fc6b2a0b355b48c8333db5abb5df4c47"

