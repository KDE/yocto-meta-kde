# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.24.2/kscreen-5.24.2.tar.xz"
SRC_URI[sha256sum] = "f8549747eaaca0a7172e57d404207a684ef659ee107c2b2815526d5d5180f489"

