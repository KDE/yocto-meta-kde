# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.1.4/powerdevil-6.1.4.tar.xz"
SRC_URI[sha256sum] = "a1a966e2e2498305e33397ef27dfa68d10255fcb7099b0d91c5eda8d429013e5"

