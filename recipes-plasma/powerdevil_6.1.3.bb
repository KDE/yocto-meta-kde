# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.1.3/powerdevil-6.1.3.tar.xz"
SRC_URI[sha256sum] = "624f8c9498056d3c7065bb72a61a381fa2021dc36f5a1f32c735435b239918f3"

