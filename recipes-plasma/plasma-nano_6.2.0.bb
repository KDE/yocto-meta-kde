# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.0/plasma-nano-6.2.0.tar.xz"
SRC_URI[sha256sum] = "2addcd07fcf7ca8631fae2b9b089a01f8b7b59c0462ce40d1b2be7bb9eefbd38"

