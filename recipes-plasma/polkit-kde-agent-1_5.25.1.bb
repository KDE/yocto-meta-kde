# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.25.1/polkit-kde-agent-1-5.25.1.tar.xz"
SRC_URI[sha256sum] = "8435a445f5ef270925ffcdd585381872a7b03728f2bdd4f8b12e069a00565c29"

