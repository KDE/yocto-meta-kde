# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.4/xdg-desktop-portal-kde-6.2.4.tar.xz"
SRC_URI[sha256sum] = "daf2d8769d0f45264ef1f48b63f5274446222574ff832e40f21d06a4c3822d1d"

