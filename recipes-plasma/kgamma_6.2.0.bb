# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.0/kgamma-6.2.0.tar.xz"
SRC_URI[sha256sum] = "5244384ae28d92b0555e9c67d5995646ff9b10371eb36b07dd14b934779e6cfc"

