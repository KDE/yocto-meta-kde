# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/5.27.4/kpipewire-5.27.4.tar.xz"
SRC_URI[sha256sum] = "a653408693ea16fee1b12a447982af48823aae86e5813b30b5a889cd2b883165"

