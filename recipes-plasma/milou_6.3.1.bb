# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.1/milou-6.3.1.tar.xz"
SRC_URI[sha256sum] = "a4d0bfaacbbd2bd513e2f7b0d8cbbd7aa1509d7ff228b8c0e1d1b2e5c1e0288d"

