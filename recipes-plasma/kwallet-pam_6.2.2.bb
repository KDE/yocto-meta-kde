# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.2/kwallet-pam-6.2.2.tar.xz"
SRC_URI[sha256sum] = "27bbfaaf64f1bef9a7dfabb2a76b5cf226d2e70f4cad9b740ff8042c5b826a87"

