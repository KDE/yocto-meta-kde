# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.93.0/plasma-workspace-5.93.0.tar.xz"
SRC_URI[sha256sum] = "db1dbd893c713d8db8f6ff2d3e5a991d2913cc66709ae0c4802aa7687d8bf673"

