# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.1.4/plasma-activities-6.1.4.tar.xz"
SRC_URI[sha256sum] = "ecb39579234bffeb8f518ab7d1964091b316f0f97c251c890992ee77b8f52286"

