# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.24.2/kdecoration-5.24.2.tar.xz"
SRC_URI[sha256sum] = "ac5f02324a5d64e81408c30f3c9d077da460b77278eed7f195344d3f5acc8d87"

