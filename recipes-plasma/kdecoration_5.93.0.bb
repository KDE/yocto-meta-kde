# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.93.0/kdecoration-5.93.0.tar.xz"
SRC_URI[sha256sum] = "e244040dc81a511d2744bc8e8fbcae4ab4de03005edf7cd50ed1bf8798b3a2e6"

