# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "git://anongit.kde.org/kscreen;nobranch=1;protocol=https"
SRCREV = "9d27bd376b85842c36bdbd0777329fea874f2862"
S = "${WORKDIR}/git"
