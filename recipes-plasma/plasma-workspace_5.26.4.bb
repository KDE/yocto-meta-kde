# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.26.4/plasma-workspace-5.26.4.tar.xz"
SRC_URI[sha256sum] = "c9051cda4b6d7386e743a4cf24315b07bbf7a396494899de1b06df87287ceb1a"

