# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.91.0/kde-cli-tools-5.91.0.tar.xz"
SRC_URI[sha256sum] = "81a610b7f505d17539dbbc675c551dfc5fd196da05ae73adb98dc4e109f0b7c3"

