# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.4/bluedevil-6.2.4.tar.xz"
SRC_URI[sha256sum] = "e664a8dd1be5570356922ec8578bd91a2db86656a676c1c86db9c3cefdbea202"

