# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.24.5/libkscreen-5.24.5.tar.xz"
SRC_URI[sha256sum] = "7ff118af3320e53d2c1cb9f324d2ee13d087062ef354d219f20503da5ac06fc9"

