# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.4/discover-6.3.4.tar.xz"
SRC_URI[sha256sum] = "2a18caed673493cbeb840aa166626d4283272c97578af0bf67e8887b672cf3d8"

