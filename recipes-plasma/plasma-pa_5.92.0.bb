# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.92.0/plasma-pa-5.92.0.tar.xz"
SRC_URI[sha256sum] = "8c65a2f384f6948712e13560f6bccf8906a7d210e61a19580d660d7b5c5edecd"

