# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.1.4/plasma-systemmonitor-6.1.4.tar.xz"
SRC_URI[sha256sum] = "262a48d29da061bc76aa7c24904d4828bc2dec0b6640acffce3799194c4be457"

