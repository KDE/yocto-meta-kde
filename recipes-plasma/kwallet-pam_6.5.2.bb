# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.5.2/kwallet-pam-6.5.2.tar.xz"
SRC_URI[sha256sum] = "5fc3faa59411eed74283d6aa54c2debfc7e6a2b3088d7051ae62fdf6268ae876"

