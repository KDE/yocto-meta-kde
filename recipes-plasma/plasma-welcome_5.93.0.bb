# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.93.0/plasma-welcome-5.93.0.tar.xz"
SRC_URI[sha256sum] = "61671dd925dae784c4f4ccdca547b214f9cbf59febe1024b7904cc42dd3d3356"

