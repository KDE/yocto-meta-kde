# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.26.4/kde-cli-tools-5.26.4.tar.xz"
SRC_URI[sha256sum] = "1fc96d511305ec948127646c247c9ee71de8303497ebaa246b1ce53aaa1cd84f"

