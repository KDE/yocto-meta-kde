# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/unstable/plasma/5.91.0/plasma-desktop-5.91.0.tar.xz"
SRC_URI[sha256sum] = "8ad0903464e1eaa79446ec77f64b26b95b8ca2d078c035e54c13bf5f5f426160"

