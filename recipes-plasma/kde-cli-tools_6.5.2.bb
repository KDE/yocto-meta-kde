# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.5.2/kde-cli-tools-6.5.2.tar.xz"
SRC_URI[sha256sum] = "834f1da71ec6f9eb2d0560218080a0f02a00cd6609c9ed5464011700c28a0a1c"

