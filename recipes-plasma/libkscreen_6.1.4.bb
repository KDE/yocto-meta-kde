# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.1.4/libkscreen-6.1.4.tar.xz"
SRC_URI[sha256sum] = "730262beecbc6270b96afc0d3fbbfeb546b4e383889222b385d07aecb42c667b"

