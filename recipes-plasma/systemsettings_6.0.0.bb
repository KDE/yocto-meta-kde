# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.0.0/systemsettings-6.0.0.tar.xz"
SRC_URI[sha256sum] = "561f9013ba07071c0add777858ec85d40a8dddfcc83a10f5f04b2ce1016666bc"

