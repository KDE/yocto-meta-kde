# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.1.4/plasma-activities-stats-6.1.4.tar.xz"
SRC_URI[sha256sum] = "92fae6bf29594c5fe99625086bc94f5bbab992760f96d6b4324e93c5ec7f2077"

