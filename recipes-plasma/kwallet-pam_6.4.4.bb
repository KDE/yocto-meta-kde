# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.4.4/kwallet-pam-6.4.4.tar.xz"
SRC_URI[sha256sum] = "e464f9bc73a4db2b593d1b19e1e8aee385d155513e58b6b11470fa78c52efbc1"

