# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.26.4/xdg-desktop-portal-kde-5.26.4.tar.xz"
SRC_URI[sha256sum] = "63361d6b157da8df04625ccb57442b6230f5c08d4554c26b3c25d429411c7f9c"

