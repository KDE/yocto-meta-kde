# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.24.5/layer-shell-qt-5.24.5.tar.xz"
SRC_URI[sha256sum] = "f591600cc0697cc94ce765bd17b1f9e3ab52d3d58c4de89e2820de3a7377b279"

