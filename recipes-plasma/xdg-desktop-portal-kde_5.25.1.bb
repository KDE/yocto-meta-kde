# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.25.1/xdg-desktop-portal-kde-5.25.1.tar.xz"
SRC_URI[sha256sum] = "1ac0d78db205abe5d0b68f5f230f264b77940cfb2c019cec8d8c62da54e66995"

