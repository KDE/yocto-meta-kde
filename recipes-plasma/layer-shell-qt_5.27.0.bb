# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.27.0/layer-shell-qt-5.27.0.tar.xz"
SRC_URI[sha256sum] = "9c0d4737929a80c97c4084a13391ee2ff94ea5bfa1f82f1a11ce0fbedcb943ff"

