# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.2.0/libplasma-6.2.0.tar.xz"
SRC_URI[sha256sum] = "756a1cb01513ca04906a079cc2802dca6f4f610f319261919b3d5e25bd4fda98"

