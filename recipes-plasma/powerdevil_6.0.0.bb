# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.0.0/powerdevil-6.0.0.tar.xz"
SRC_URI[sha256sum] = "126342760e1b8ca4b98fa8579abcaa415b859d7d6d1802b36a025648672cb050"

