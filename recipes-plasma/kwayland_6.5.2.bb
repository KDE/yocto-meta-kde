# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.5.2/kwayland-6.5.2.tar.xz"
SRC_URI[sha256sum] = "aa63e3753e241f3955eb806ae91af1f3963e42ec731f2b8a2330119b65cb557a"

