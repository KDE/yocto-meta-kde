# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.1/libkscreen-6.3.1.tar.xz"
SRC_URI[sha256sum] = "86327eedb42c4a632e376116c28e108a81fca0ec6658688ba22aaae6164c88a2"

