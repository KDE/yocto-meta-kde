# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.26.4/plank-player-5.26.4.tar.xz"
SRC_URI[sha256sum] = "978fb89c7cb525b61e1e73aabf67b5c8e4b0e2ccfc76c0ed03ee15245dd15a2c"

