# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.0.2/plasma-systemmonitor-6.0.2.tar.xz"
SRC_URI[sha256sum] = "bc3573797b99de96e399a29362ebcf6e1bb989ced4a1c419f2322048426c938b"

