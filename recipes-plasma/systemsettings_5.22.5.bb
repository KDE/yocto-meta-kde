# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.22.5/systemsettings-5.22.5.tar.xz"
SRC_URI[sha256sum] = "cc7978faa1c3fcf75584a09459e69e665c17514dcf59e07287e1d80aadb975bb"

