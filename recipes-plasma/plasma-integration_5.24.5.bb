# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma/5.24.5/plasma-integration-5.24.5.tar.xz"
SRC_URI[sha256sum] = "cd4490e1e23276bd4f7827ec1c6a3dee6703b8065bd5b4f3fad8112b53eadf7a"

