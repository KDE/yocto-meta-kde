# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.4.4/ocean-sound-theme-6.4.4.tar.xz"
SRC_URI[sha256sum] = "ddd87c9021947a5eff06e2f92566b9d81fe06ea444430745e896d647994e37eb"

