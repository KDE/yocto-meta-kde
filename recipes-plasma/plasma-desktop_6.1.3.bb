# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.1.3/plasma-desktop-6.1.3.tar.xz"
SRC_URI[sha256sum] = "362f64fa1af1c295d7fdade146bf5751176256c19fd41dd1850fff3603c21fad"

