# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/plasma/6.3.1/kscreen-6.3.1.tar.xz"
SRC_URI[sha256sum] = "b07cf8f12bab68d36fbb5612f5e3cffdc9e9a966454b1c47b7b37fb7bcf040b2"

