# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.95/src/kdeedu-data-24.01.95.tar.xz"
SRC_URI[sha256sum] = "67610639bbf92c2ee92677c436a2083890f651c6ab4d7a5a064981daa28eed3b"
