# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.08.0/src/libkeduvocdocument-25.08.0.tar.xz"
SRC_URI[sha256sum] = "b6739f73e41c5df9ee312011985f75bd2e74200e78a7cba771958bb1f029517a"
