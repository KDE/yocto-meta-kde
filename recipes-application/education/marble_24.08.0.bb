# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.08.0/src/marble-24.08.0.tar.xz"
SRC_URI[sha256sum] = "bc02c709c15518fa1c6a7dafef2c507e14571d4f722486faca1bf8e18be931a5"
