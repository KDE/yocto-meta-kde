# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/22.04.3/src/khangman-22.04.3.tar.xz"
SRC_URI[sha256sum] = "8aaa989a50a88a712f29841a79ba7ebe6dbebd9584dc5bec0a249f36ffb5aa03"
