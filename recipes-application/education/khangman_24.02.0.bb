# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.02.0/src/khangman-24.02.0.tar.xz"
SRC_URI[sha256sum] = "0ec05c56466611ea4c4b86dad2f90d46d732529fd1d4b749b0f2f14d2f36a6f1"
