# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.75/src/kdeedu-data-24.01.75.tar.xz"
SRC_URI[sha256sum] = "333b490395d23bc4f081ea0f43aac78fe8fa7ad868d3357422c5e7dd56d80a51"
