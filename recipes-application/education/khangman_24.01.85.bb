# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.85/src/khangman-24.01.85.tar.xz"
SRC_URI[sha256sum] = "4773ef0692529ea9e1faf1d748f28eb673852dffc08ffc6ac2dd3ad8a972b8ca"
