# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.95/src/khangman-24.01.95.tar.xz"
SRC_URI[sha256sum] = "605e41587b1d433b3eaf9f7b5f27cac491e2540ac1a08b9cc73a45ce161eca23"
