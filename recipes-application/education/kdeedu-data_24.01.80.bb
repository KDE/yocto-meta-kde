# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.80/src/kdeedu-data-24.01.80.tar.xz"
SRC_URI[sha256sum] = "d3ddafb61489c769295a5c7dd2cc78e0625cd97143f3b6ae60bf77e81cc4f7e4"
