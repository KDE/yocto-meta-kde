# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.04.0/src/kwordquiz-25.04.0.tar.xz"
SRC_URI[sha256sum] = "0d6a3947c4db66b56c6a4c7dfec46d5a6e86b5bcf727de7c33561388a6e91a80"
