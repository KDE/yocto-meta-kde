# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/22.04.3/src/kdeedu-data-22.04.3.tar.xz"
SRC_URI[sha256sum] = "320463fe32177e49ffb4747f890d83b471f091477473439bfe0531b0ba5fb3e4"
