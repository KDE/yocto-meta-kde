# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.08.3/src/kwordquiz-24.08.3.tar.xz"
SRC_URI[sha256sum] = "e2fb02c238d6f67b7acfc8d3dc4e7ebd4644be6a9e30c87a9ec3cb453a20aa1a"
