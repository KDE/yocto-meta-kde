# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/26.04.1/src/libkeduvocdocument-26.04.1.tar.xz"
SRC_URI[sha256sum] = "2994fa1b3c66dcb20d969147fffef28faf375c073b29aeda37db5f3432c21e29"
