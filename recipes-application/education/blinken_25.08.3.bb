# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.08.3/src/blinken-25.08.3.tar.xz"
SRC_URI[sha256sum] = "770598f227e8cbb69b4b0dde4e3ba6dea1074e3e0a8a7f07e4243a18bf876d6d"
