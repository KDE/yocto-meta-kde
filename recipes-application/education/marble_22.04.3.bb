# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/22.04.3/src/marble-22.04.3.tar.xz"
SRC_URI[sha256sum] = "438d4ef317231b8f2377f64ebfe9249ce669103fb71105c9d7de35a39bbef771"
