# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.08.3/src/kdeedu-data-24.08.3.tar.xz"
SRC_URI[sha256sum] = "1ce17eb4e7070d3ffa7cfaaecd2d97b1c52bdf3c39187d880f708f6f2ffaa28f"
