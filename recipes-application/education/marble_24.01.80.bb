# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.80/src/marble-24.01.80.tar.xz"
SRC_URI[sha256sum] = "f88959647ebbe77e1a5b6e62f813be4a01d67126f23943bea914cc588e25fda9"
