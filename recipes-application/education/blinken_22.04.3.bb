# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/22.04.3/src/blinken-22.04.3.tar.xz"
SRC_URI[sha256sum] = "67b47d9db2e656822a10a7c065c8299cd6acdbcbd0baa4bb766fac7974700467"
