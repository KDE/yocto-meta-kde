# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.08.0/src/kwordquiz-24.08.0.tar.xz"
SRC_URI[sha256sum] = "79b471f98e1cb836dbc4c95e5b7dc295739fda3f7360873e8405458324c0e41c"
