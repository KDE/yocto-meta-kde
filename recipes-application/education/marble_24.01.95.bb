# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.95/src/marble-24.01.95.tar.xz"
SRC_URI[sha256sum] = "23f25f438c6f690331e354f4bf361c3731cbb90ca4ab6278f956719cd05bdaf2"
