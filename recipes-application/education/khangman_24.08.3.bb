# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.08.3/src/khangman-24.08.3.tar.xz"
SRC_URI[sha256sum] = "adedc00e472750b0a4397d5babdf57871901098f998d046573a975ed95eefc84"
