# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.04.0/src/khangman-25.04.0.tar.xz"
SRC_URI[sha256sum] = "ef1b64d67f82da8063d9f33ce30541f1eaafcc4df644605b77d766ec2e876ab2"
