# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.90/src/kdeedu-data-24.01.90.tar.xz"
SRC_URI[sha256sum] = "7bc4309225f1edddab3196f20e8520eb5bb313abb7bb59a8a74684bb9a000dd4"
