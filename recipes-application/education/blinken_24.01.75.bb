# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.75/src/blinken-24.01.75.tar.xz"
SRC_URI[sha256sum] = "e55cd411e452a23c6ee5df068a5310ea621335339cd3e605d2daa2beeb148d8e"
