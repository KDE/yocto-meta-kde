# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/22.04.3/src/kanagram-22.04.3.tar.xz"
SRC_URI[sha256sum] = "7ea87105e98c350a65027d19dab7e519770daffe90e6360671e3e7a08cb6a5af"
