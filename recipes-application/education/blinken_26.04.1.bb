# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/26.04.1/src/blinken-26.04.1.tar.xz"
SRC_URI[sha256sum] = "d098f0788177da717c57ae63793f3bb11e20ee287d788efeb8caa5a885864c4f"
