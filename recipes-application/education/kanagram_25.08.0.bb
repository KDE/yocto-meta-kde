# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.08.0/src/kanagram-25.08.0.tar.xz"
SRC_URI[sha256sum] = "a8086e3f8a8a8faf40878d439aa754641444d93c8b0d0c529047530abdf46406"
