# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.80/src/khangman-24.01.80.tar.xz"
SRC_URI[sha256sum] = "4a21bc11fc8dff3ca8beec01159dd545aeb4dde07f243a2c49d8f277c28a39e8"
