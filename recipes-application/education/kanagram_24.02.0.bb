# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.02.0/src/kanagram-24.02.0.tar.xz"
SRC_URI[sha256sum] = "5a0737c24b89d7a4661fbdc9f3435774e3e17bb6db440eb43708d81f4cda8195"
