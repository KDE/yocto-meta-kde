# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.08.0/src/kwordquiz-25.08.0.tar.xz"
SRC_URI[sha256sum] = "0b3c71fc33526d060976db0e1d4d88b5e965a5bef144ad0be828c783e8f4167d"
