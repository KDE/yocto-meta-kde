# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.12.1/src/kanagram-25.12.1.tar.xz"
SRC_URI[sha256sum] = "7716e0fb91436e05dd32789044a4ae4d1632167db3b7850fbb3169a1f00c10c7"
