# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.08.3/src/kanagram-24.08.3.tar.xz"
SRC_URI[sha256sum] = "97e60c6be79b88836a0f2214f28e8ca1b7b73415a8244eb804381e1482d8b4fb"
