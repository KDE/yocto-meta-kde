# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.95/src/blinken-24.01.95.tar.xz"
SRC_URI[sha256sum] = "2c2749dadcd190e3996e001c9fd46f075359fef151ed1cbb27413d0cbfdd8652"
