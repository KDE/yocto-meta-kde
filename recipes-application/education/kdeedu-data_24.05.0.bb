# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.05.0/src/kdeedu-data-24.05.0.tar.xz"
SRC_URI[sha256sum] = "6bde55cf75872b39f634e39ce4d2bf0f58682e7a0734c7ecb0e9c263687e96a3"
