# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.08.3/src/kanagram-25.08.3.tar.xz"
SRC_URI[sha256sum] = "c15a2a0b2c08cef7455220eeddfcc3095d36eea14d684fc5fb9ff2f1d0a5cbbc"
