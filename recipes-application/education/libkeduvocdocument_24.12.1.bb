# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.12.1/src/libkeduvocdocument-24.12.1.tar.xz"
SRC_URI[sha256sum] = "0be2a6d70161a14e9497b4359ce0ea13520d54293a5db108238a05bcb38f87b9"
