# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.02.0/src/marble-24.02.0.tar.xz"
SRC_URI[sha256sum] = "9299073ca61724350f3236c9916ea81d4bd445009ec65b736660a4bf016ef96a"
