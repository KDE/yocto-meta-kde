# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.05.0/src/blinken-24.05.0.tar.xz"
SRC_URI[sha256sum] = "58bd0dc72d20e70d2d2501518e6e10cc9ec3fa9c024aa6d09a7b28ca55842844"
