# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.04.0/src/blinken-25.04.0.tar.xz"
SRC_URI[sha256sum] = "7f9e1d8ccc4920e499d4632be88ba7193f50d8db74379df6f0b9a30561b4a0e3"
