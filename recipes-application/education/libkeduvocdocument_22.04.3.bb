# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/22.04.3/src/libkeduvocdocument-22.04.3.tar.xz"
SRC_URI[sha256sum] = "02a4b5945c938c119784b8e9d96778f613e6f2d6ddb9615f71c8c8cae07d6033"
