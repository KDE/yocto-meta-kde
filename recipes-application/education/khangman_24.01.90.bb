# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.90/src/khangman-24.01.90.tar.xz"
SRC_URI[sha256sum] = "342482d18ab7a14e4009bdf834e37744e9711deefb1ba456f0b7601547579f67"
