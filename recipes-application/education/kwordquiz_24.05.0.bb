# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.05.0/src/kwordquiz-24.05.0.tar.xz"
SRC_URI[sha256sum] = "6a4879b79dee390a01f41a14cc0e50427d83a230d9773ade4adfaf9a4740358d"
