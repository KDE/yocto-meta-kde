# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.05.0/src/kanagram-24.05.0.tar.xz"
SRC_URI[sha256sum] = "c7edc682574f486c4aaddc0468336d838fdfbef33befd6a3afcd16d9ea651d9f"
