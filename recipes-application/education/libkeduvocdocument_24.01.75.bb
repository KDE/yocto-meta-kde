# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.75/src/libkeduvocdocument-24.01.75.tar.xz"
SRC_URI[sha256sum] = "ef963329273ea6af557c78346cd707c4a448f49e4d147f749eebfce56e58dbb8"
