# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.04.0/src/marble-25.04.0.tar.xz"
SRC_URI[sha256sum] = "27bdf174215a66136795ef3d0a7a2f3e09d21b12d2c83ec3309d84389dd52909"
