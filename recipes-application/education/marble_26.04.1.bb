# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/26.04.1/src/marble-26.04.1.tar.xz"
SRC_URI[sha256sum] = "174bebba04548939f84a274553994f1231917ce437405f0f62050dfd7704ff11"
