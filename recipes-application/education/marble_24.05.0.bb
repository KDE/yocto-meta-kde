# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.05.0/src/marble-24.05.0.tar.xz"
SRC_URI[sha256sum] = "e17a2a087cda4203d858d0cbae54dd4c8d1238014afa4e532fb80dbe3f1ba9a6"
