# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.08.3/src/kdeedu-data-25.08.3.tar.xz"
SRC_URI[sha256sum] = "71f8572b57d0edb073429e2f394145911c08368b20caa3685cf64cadbc6fa2aa"
