# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.04.0/src/libkeduvocdocument-25.04.0.tar.xz"
SRC_URI[sha256sum] = "668cc42e47d21879033f7fbf133dbe0d717d3b7890019305d06b4b1eb35579fd"
