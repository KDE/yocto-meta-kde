# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.12.1/src/kdeedu-data-24.12.1.tar.xz"
SRC_URI[sha256sum] = "865316c0120f8057ef0480144b536219938f5275005903575d24f1556c454468"
