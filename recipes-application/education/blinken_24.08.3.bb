# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.08.3/src/blinken-24.08.3.tar.xz"
SRC_URI[sha256sum] = "048b4a94442a67ca76a0412db0f6cf7f9628c4d5afc4385d7e6c68109aefaeb6"
