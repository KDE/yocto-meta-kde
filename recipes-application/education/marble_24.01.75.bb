# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.75/src/marble-24.01.75.tar.xz"
SRC_URI[sha256sum] = "f8fe1d68b0b463e79be733b85c03e76f6404f9a238cc9346f271047ec9594ff8"
