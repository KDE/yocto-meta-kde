# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.08.3/src/libkeduvocdocument-25.08.3.tar.xz"
SRC_URI[sha256sum] = "b4dcc43c1d8f711d5b9ac0a29d78e2ec7710b5bcd80f1ec62534e8b1b0ebddc5"
