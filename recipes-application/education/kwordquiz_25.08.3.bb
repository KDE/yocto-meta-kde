# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.08.3/src/kwordquiz-25.08.3.tar.xz"
SRC_URI[sha256sum] = "143ded0aeea02036de7aadbd3b6ce810d0066a73dcc82d367b171962a8121684"
