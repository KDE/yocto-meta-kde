# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.90/src/blinken-24.01.90.tar.xz"
SRC_URI[sha256sum] = "395f682689802e3191ff55a435123c6d0da30ca9166c40d28c6d199ce43d89de"
