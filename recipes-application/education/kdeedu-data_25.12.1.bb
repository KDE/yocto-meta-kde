# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.12.1/src/kdeedu-data-25.12.1.tar.xz"
SRC_URI[sha256sum] = "eabb29c0da699161888256987314a7510d1a23128404ea54b70a0c90988b60bf"
