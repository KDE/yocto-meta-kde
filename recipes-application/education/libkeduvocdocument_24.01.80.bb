# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.80/src/libkeduvocdocument-24.01.80.tar.xz"
SRC_URI[sha256sum] = "6cb16bd30dfe59685572e1cfc6f906b34be4d635bb439ad7721b2686e2774836"
