# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.85/src/blinken-24.01.85.tar.xz"
SRC_URI[sha256sum] = "fe3e60e8ab03e9333d5718f26b2ec85ee9096f1caa7d41f475d3e3a935769cb5"
