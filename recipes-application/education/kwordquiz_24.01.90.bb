# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.90/src/kwordquiz-24.01.90.tar.xz"
SRC_URI[sha256sum] = "ca0d487ae4074e70cd1417b2ea66e24dfb508ed082fe243ff9c3ba69fd172b51"
