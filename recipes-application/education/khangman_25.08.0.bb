# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.08.0/src/khangman-25.08.0.tar.xz"
SRC_URI[sha256sum] = "6e0395602370083082525717485fa1030ae7b4e31ecb97ad2035aa3c4788a890"
