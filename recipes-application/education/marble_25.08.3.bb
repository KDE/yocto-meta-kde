# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.08.3/src/marble-25.08.3.tar.xz"
SRC_URI[sha256sum] = "65c034dacc7a2d5bbf534fca6574289e8b1dbf2bd50e4f63ff4d1ab64ff07198"
