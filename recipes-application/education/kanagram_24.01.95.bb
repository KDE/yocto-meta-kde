# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.95/src/kanagram-24.01.95.tar.xz"
SRC_URI[sha256sum] = "0594e408b62158058cfc54b93356052d901c39923965ba359df194c610db62aa"
