# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.80/src/blinken-24.01.80.tar.xz"
SRC_URI[sha256sum] = "8006a61c3a9313ff519cbb58121306fb565754c4387befcf776e97bcce639cd0"
