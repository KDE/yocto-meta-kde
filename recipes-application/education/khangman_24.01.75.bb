# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.75/src/khangman-24.01.75.tar.xz"
SRC_URI[sha256sum] = "cfc27db649ca223c026f5d2ba1d68e16e840e4663b5d2a59545ef09ca875a256"
