# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.90/src/libkeduvocdocument-24.01.90.tar.xz"
SRC_URI[sha256sum] = "958ee3243cae86ebfe776d0da46280ee19df537d6bff20c7879f72f8c46c3087"
