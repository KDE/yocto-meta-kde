INSANE_SKIP:${PN}-src += "buildpaths"
