# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.12.1/src/blinken-24.12.1.tar.xz"
SRC_URI[sha256sum] = "d33edf9f813bede02e2bed3a40ebd1c8beccde30edd3fa428b3cc9eeee44ce54"
