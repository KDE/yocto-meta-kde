# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.12.1/src/libkeduvocdocument-25.12.1.tar.xz"
SRC_URI[sha256sum] = "b7810389709cf3cab36a1f4fd1b255581844ce26cc9487cbfc956a68e61143e2"
