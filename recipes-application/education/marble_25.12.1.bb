# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.12.1/src/marble-25.12.1.tar.xz"
SRC_URI[sha256sum] = "09c2a8459640b3b114ea40d819bc61b0051cf982572f61aeb31c04190f488717"
