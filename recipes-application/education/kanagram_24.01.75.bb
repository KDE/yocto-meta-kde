# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.75/src/kanagram-24.01.75.tar.xz"
SRC_URI[sha256sum] = "26fa652fb3710d963ad10de8ba9bb302a85dfe0c9ff4b8facd1f40e48e645281"
