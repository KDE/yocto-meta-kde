# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/26.04.1/src/kdeedu-data-26.04.1.tar.xz"
SRC_URI[sha256sum] = "7330c192cc95bf25b58cc442bc1eab8a7e981cb4c2903cb02487e99c9de7a41a"
