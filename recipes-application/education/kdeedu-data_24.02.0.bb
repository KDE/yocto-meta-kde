# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.02.0/src/kdeedu-data-24.02.0.tar.xz"
SRC_URI[sha256sum] = "0a5d9a90c6147679ff36ccd5d0f8607598e3d89fd13e529ac1d65092ca17ef6f"
