# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.12.1/src/khangman-25.12.1.tar.xz"
SRC_URI[sha256sum] = "9712dcc169b59243d2a3234087a3c8fa51500c660654430e16c565716678bb5f"
