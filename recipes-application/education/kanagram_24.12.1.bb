# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.12.1/src/kanagram-24.12.1.tar.xz"
SRC_URI[sha256sum] = "d2ddba6a4be148e05aea07e53365ed8d7149dde25f61cf60f19a815268c237fb"
