# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.95/src/kwordquiz-24.01.95.tar.xz"
SRC_URI[sha256sum] = "da21190f0c598b87ea2141c3c920200f4aeec44f479bec1769e90c74f8607f8c"
