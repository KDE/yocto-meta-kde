# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.95/src/libkeduvocdocument-24.01.95.tar.xz"
SRC_URI[sha256sum] = "ef6bed5ef9fb46faf28c30e4997ec05030472450321d8cd8850656976234a46a"
