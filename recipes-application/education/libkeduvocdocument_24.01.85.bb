# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.85/src/libkeduvocdocument-24.01.85.tar.xz"
SRC_URI[sha256sum] = "276909c0484573ce718b5b2ba3a2d607f35e038aedbbf513d7637d8884b20e75"
