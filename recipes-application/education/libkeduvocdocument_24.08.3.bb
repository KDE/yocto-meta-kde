# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.08.3/src/libkeduvocdocument-24.08.3.tar.xz"
SRC_URI[sha256sum] = "d9bfd4e7f67b159352a5e6c12feef2b91eae44449515432fb72c345a37c4f1c4"
