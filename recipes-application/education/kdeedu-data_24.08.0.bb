# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.08.0/src/kdeedu-data-24.08.0.tar.xz"
SRC_URI[sha256sum] = "ce1d70e39acd3c333a8e6819573b38d83a89fcd80f3293c8c31707e604f4704c"
