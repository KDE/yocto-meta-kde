# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.90/src/marble-24.01.90.tar.xz"
SRC_URI[sha256sum] = "4ea7c897c130b9e0b9faf006880b5679463ae470e45d0aa53720e28d024131e0"
