# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.85/src/marble-24.01.85.tar.xz"
SRC_URI[sha256sum] = "d534016f14d2408290ebf3c89bbbc911b310284df26c0a278560415589849343"
