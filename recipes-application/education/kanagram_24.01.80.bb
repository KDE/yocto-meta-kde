# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.80/src/kanagram-24.01.80.tar.xz"
SRC_URI[sha256sum] = "fbf8515fa2dbee7e57d393571bf6fb0d23dea5b31476c1703f501e37dacbffca"
