# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/26.04.1/src/kanagram-26.04.1.tar.xz"
SRC_URI[sha256sum] = "e39e7ebbeee0dce822334e7b6ea2f1314826299b73eaff3173ef3b5754e22065"
