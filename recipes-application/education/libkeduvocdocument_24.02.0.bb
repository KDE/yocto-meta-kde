# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.02.0/src/libkeduvocdocument-24.02.0.tar.xz"
SRC_URI[sha256sum] = "3c8b4cc555f4f23b77044615cf82cba91ab8676445b5d25c138f96217adde31b"
