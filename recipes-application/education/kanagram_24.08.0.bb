# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.08.0/src/kanagram-24.08.0.tar.xz"
SRC_URI[sha256sum] = "e384e931351df9ad6f032d77e005a3954a78b854cd9dc2e2d2f5c376e5d8125d"
