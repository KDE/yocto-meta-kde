# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.08.3/src/marble-24.08.3.tar.xz"
SRC_URI[sha256sum] = "c53c1faa741e1b424594c2021fa4edc620528e862ceff280cb3c952d1af20371"
