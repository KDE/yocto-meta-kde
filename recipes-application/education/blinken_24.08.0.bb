# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.08.0/src/blinken-24.08.0.tar.xz"
SRC_URI[sha256sum] = "a3d558f9eb128c800ce1474457f14dc7703eb4f37ceab269b01aa3b1a5dbb83b"
