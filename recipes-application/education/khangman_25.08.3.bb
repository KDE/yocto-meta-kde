# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.08.3/src/khangman-25.08.3.tar.xz"
SRC_URI[sha256sum] = "b45f55c71fa5e2d05bc8f98cfda9d076e38d465c325cb43d39942eeb6741af72"
