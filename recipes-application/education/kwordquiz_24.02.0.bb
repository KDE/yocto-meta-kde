# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.02.0/src/kwordquiz-24.02.0.tar.xz"
SRC_URI[sha256sum] = "a6cdcf0823a7701c6e1930d7d51a717a4ca5794781054d38cf278c66e0e02fa4"
