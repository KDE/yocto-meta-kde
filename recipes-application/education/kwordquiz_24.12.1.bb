# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.12.1/src/kwordquiz-24.12.1.tar.xz"
SRC_URI[sha256sum] = "df256439ecb5421353e643bbf29e7966a2f530c96e63e432af4850d9dd6fc92a"
