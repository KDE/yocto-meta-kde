# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.85/src/kdeedu-data-24.01.85.tar.xz"
SRC_URI[sha256sum] = "368ee390f9f3f4c691fbe5a0cd151dacd11c4b28e55b628b8b058fc9f1a9ca3a"
