# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.12.1/src/blinken-25.12.1.tar.xz"
SRC_URI[sha256sum] = "f1082cc616f0efc2cd1366a61424eb4c789900a6fd05250efe8ca058e33092be"
