# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.05.0/src/khangman-24.05.0.tar.xz"
SRC_URI[sha256sum] = "3ac652b77736b4a885f1984575f60daaf9b25f80a48741226c29ef0423508ce3"
