# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.04.0/src/kdeedu-data-25.04.0.tar.xz"
SRC_URI[sha256sum] = "69d1188611029cd0aaa4b54abab3d18b7e41aff4df3c93f10f3866573c7ea729"
