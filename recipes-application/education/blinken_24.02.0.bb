# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.02.0/src/blinken-24.02.0.tar.xz"
SRC_URI[sha256sum] = "9cd5797385b40644f732997c8bf0d31f705c0687c2ecfaeb942c33d4b2a9fd74"
