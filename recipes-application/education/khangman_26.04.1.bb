# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/26.04.1/src/khangman-26.04.1.tar.xz"
SRC_URI[sha256sum] = "99618ea09efb081f230bd510af22aade1774623bf2166d69663b3b11c1aa5747"
