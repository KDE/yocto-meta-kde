# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.04.0/src/kanagram-25.04.0.tar.xz"
SRC_URI[sha256sum] = "4cd1acf2a12f4d99b4b466cc12a324cb525f8f26f63faec2cd98585981eaf2dc"
