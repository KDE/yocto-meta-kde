# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.90/src/kanagram-24.01.90.tar.xz"
SRC_URI[sha256sum] = "77e4d3e59e416ef979f4e34f46f71924f73fc65891bc15698a1e81ed364c5ed7"
