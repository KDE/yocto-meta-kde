# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.08.0/src/libkeduvocdocument-24.08.0.tar.xz"
SRC_URI[sha256sum] = "9ff94d77c66ef574bc51f5384fa3370a854524a809bab10a292ccd57d723a8c5"
