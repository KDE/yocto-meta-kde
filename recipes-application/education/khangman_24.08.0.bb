# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.08.0/src/khangman-24.08.0.tar.xz"
SRC_URI[sha256sum] = "fd116685b3c4d5f69de6fd0f0b5a2255188b9de1e278857ff75e074175ce0a9c"
