# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.12.1/src/kwordquiz-25.12.1.tar.xz"
SRC_URI[sha256sum] = "36a2b9e08dd85d801968abbd0eae286a7ec0b094f6c501b58977e49da3116712"
