# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.08.0/src/blinken-25.08.0.tar.xz"
SRC_URI[sha256sum] = "659bc69e811c7247e801c0696066bfb8cc9f70e223f401a58b08bb6bd83d35a4"
