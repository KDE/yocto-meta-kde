# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.08.0/src/kdeedu-data-25.08.0.tar.xz"
SRC_URI[sha256sum] = "5ef96eeeed941a5cebd9756c6cc1dde888a63c677a1c6250b6a2286070b92066"
