# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.12.1/src/khangman-24.12.1.tar.xz"
SRC_URI[sha256sum] = "ae4ee0820d313313371563bab42a74bc0a1a67c1290800176d27f7154030969d"
