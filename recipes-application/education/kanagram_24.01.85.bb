# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.85/src/kanagram-24.01.85.tar.xz"
SRC_URI[sha256sum] = "d6d6ec4b1f0fbc06697b4b4beb298f9f12e589effd2041a596bdaaab8fd35e5d"
