# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.08.3/src/konsole-25.08.3.tar.xz"
SRC_URI[sha256sum] = "095a7ff10df3c70779b356fb3b5984062bbc698bbed966230e3dbccf6af36615"