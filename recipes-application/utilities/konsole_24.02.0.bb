# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.02.0/src/konsole-24.02.0.tar.xz"
SRC_URI[sha256sum] = "2915edcd856552bd6199efb23dcaf194605ee4fb307c75e27606198253dfdfe0"
