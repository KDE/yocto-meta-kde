# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/22.04.3/src/kdialog-22.04.3.tar.xz"
SRC_URI[sha256sum] = "c0fd9708b17ffa016fc54eacffac6735e0db82b4812208ef9ffd41c9d36fff33"
