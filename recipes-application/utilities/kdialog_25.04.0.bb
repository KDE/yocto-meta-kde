# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.04.0/src/kdialog-25.04.0.tar.xz"
SRC_URI[sha256sum] = "563db383cd9c20c387c34b920755f52e14684f8bca2a1f7deecf76c1e0e0d639"
