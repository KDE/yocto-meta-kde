# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.08.0/src/dolphin-25.08.0.tar.xz"
SRC_URI[sha256sum] = "ddd5e5622594792490695999188c6215c3a0821787c71dfb57dbfdd08e1ce935"
