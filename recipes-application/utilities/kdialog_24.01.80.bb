# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.80/src/kdialog-24.01.80.tar.xz"
SRC_URI[sha256sum] = "0ede0570dac89acd0a2c298cf25416942018add72b5f2b98f62d02d671fc5324"
