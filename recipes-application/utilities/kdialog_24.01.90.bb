# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.90/src/kdialog-24.01.90.tar.xz"
SRC_URI[sha256sum] = "1962592a21a65ca1db22318d1dfb94bc5c5ec0c14225842101ac06decde9b31d"
