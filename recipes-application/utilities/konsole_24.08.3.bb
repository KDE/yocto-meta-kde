# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.08.3/src/konsole-24.08.3.tar.xz"
SRC_URI[sha256sum] = "687498a7eb8050549fd9a5bc94212f1cc7f33b81fee406b64a1ef6b7c65058da"
