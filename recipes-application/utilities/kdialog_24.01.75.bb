# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.75/src/kdialog-24.01.75.tar.xz"
SRC_URI[sha256sum] = "2c75e49a8290f4f8c6e237c5b55bec31c0c612c124944c4f12107995ec5861d2"
