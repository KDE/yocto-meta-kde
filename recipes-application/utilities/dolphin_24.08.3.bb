# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.08.3/src/dolphin-24.08.3.tar.xz"
SRC_URI[sha256sum] = "95bbce876019fb0c7cc6ca4a5fd8ec1f625f70fd511fe883df12446a5285806d"
