# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/26.04.1/src/kdialog-26.04.1.tar.xz"
SRC_URI[sha256sum] = "64714ea3e68b207223e3867587966d6aff57f1e2ef282b1f09786c4f4244ae01"
