# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.08.0/src/konsole-24.08.0.tar.xz"
SRC_URI[sha256sum] = "0095f1afc4e4a4cd36a12a2927e090e62fb0d016d38914bc858af568b7416101"
