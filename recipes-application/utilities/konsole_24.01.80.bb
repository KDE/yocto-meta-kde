# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.80/src/konsole-24.01.80.tar.xz"
SRC_URI[sha256sum] = "55d166f23e40fe48bdd343655b0c14240260282cecd69d650a085d1713a34402"
