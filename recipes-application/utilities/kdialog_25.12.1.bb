# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.12.1/src/kdialog-25.12.1.tar.xz"
SRC_URI[sha256sum] = "102d6135531b8762c2c3378442d1cff82f3d6718097262df17503121e0ae2a02"
