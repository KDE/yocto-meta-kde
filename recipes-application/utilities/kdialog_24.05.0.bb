# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.05.0/src/kdialog-24.05.0.tar.xz"
SRC_URI[sha256sum] = "8b7d922affbb415af0cfd43de8612e1dad8eb3e5b8d3f43284f1bd50dee0b240"
