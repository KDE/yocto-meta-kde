# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.08.0/src/konsole-25.08.0.tar.xz"
SRC_URI[sha256sum] = "c880bd2c829437a142abaf4f97ebc384c9f2c19f31cc23918c49100727927450"
