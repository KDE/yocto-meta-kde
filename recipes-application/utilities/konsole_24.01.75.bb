# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.75/src/konsole-24.01.75.tar.xz"
SRC_URI[sha256sum] = "7d0385978c608a748e678612bb72f78d1c8636afcca3d2014ee720f12a2ce43d"
