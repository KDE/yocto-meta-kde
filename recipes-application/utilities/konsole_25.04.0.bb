# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.04.0/src/konsole-25.04.0.tar.xz"
SRC_URI[sha256sum] = "d326dba57b17331e5030ed6babdea1d33876bc011f9c9faa029f965ae73a79d1"
