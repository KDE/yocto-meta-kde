# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.05.0/src/konsole-24.05.0.tar.xz"
SRC_URI[sha256sum] = "53efd25c1d574448db57f446f423328c7f2f08889f67defc1ed5c783c9ef47f4"
