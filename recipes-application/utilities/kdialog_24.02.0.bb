# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.02.0/src/kdialog-24.02.0.tar.xz"
SRC_URI[sha256sum] = "774a1d1faa025b6882ef65e806d73a7d19560a560e9c1cdeacc0202b01f0bddd"
