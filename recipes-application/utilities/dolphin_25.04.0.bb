# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.04.0/src/dolphin-25.04.0.tar.xz"
SRC_URI[sha256sum] = "8997ec04ef12af22647dfef67b15ea8f1304f7ae076c7b8fd53184a55a012a18"
