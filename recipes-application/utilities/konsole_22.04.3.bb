# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/22.04.3/src/konsole-22.04.3.tar.xz"
SRC_URI[sha256sum] = "148f65891318e6a6f31793c9535e2bf32068b1cae8c5026e54f360bea484d9a7"
