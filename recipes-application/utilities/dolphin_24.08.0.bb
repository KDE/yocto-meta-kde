# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.08.0/src/dolphin-24.08.0.tar.xz"
SRC_URI[sha256sum] = "4a9d52dcd6513d2193c0c34944b270b399150f1da4ff37da06a0f8af87f6d8d7"
