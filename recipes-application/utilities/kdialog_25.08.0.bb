# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.08.0/src/kdialog-25.08.0.tar.xz"
SRC_URI[sha256sum] = "7772cdfe2acccfda420c627a8b1f4cf35acc1906f5155fc2166ee482e10755a3"
