# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.08.3/src/kdialog-25.08.3.tar.xz"
SRC_URI[sha256sum] = "d2c9fc33ecb48a2d135643b83e700b9212d1e80fd651971c035bfaf328dfbab4"
