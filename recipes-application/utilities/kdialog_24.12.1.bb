# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.12.1/src/kdialog-24.12.1.tar.xz"
SRC_URI[sha256sum] = "01d541202b2c94f8be92bab467f8b962430cd32fc1b8d64d0122cdd0bbd3a4b7"
