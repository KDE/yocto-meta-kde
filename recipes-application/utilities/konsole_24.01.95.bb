# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.95/src/konsole-24.01.95.tar.xz"
SRC_URI[sha256sum] = "8468e7042df2b3c53ae7de4ffbe2c20c38d2d586d8cd07a97bc0c1e7fa9ca882"
