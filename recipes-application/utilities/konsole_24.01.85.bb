# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.85/src/konsole-24.01.85.tar.xz"
SRC_URI[sha256sum] = "691e96f07c3654cd8ff08276c2d01a24c4ad2d96c3265d4d6da2de9b05bf5d14"
