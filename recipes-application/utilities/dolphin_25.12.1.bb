# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.12.1/src/dolphin-25.12.1.tar.xz"
SRC_URI[sha256sum] = "86315327422175a483e3efc61f7e7fff954d4f760efdcfff5f8713a3d10db664"
