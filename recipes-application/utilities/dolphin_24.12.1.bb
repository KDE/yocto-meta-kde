# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.12.1/src/dolphin-24.12.1.tar.xz"
SRC_URI[sha256sum] = "481c0aaa2186354e091256332df1b1c5ca14bec8b59bc8c1e75b6934830a8663"
