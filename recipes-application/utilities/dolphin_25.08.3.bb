# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.08.3/src/dolphin-25.08.3.tar.xz"
SRC_URI[sha256sum] = "1abd632ebe3837df5616216f69c3ca9f6240165f9f84502422203275eaa8ee09"
