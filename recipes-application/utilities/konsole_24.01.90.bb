# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.90/src/konsole-24.01.90.tar.xz"
SRC_URI[sha256sum] = "300b9c41bddb267d7a0cc260102c5bb0449a912699eea2a88cacbf8f4eccb231"
