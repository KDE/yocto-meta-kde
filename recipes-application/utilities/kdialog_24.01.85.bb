# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.85/src/kdialog-24.01.85.tar.xz"
SRC_URI[sha256sum] = "3734b72953ed1ec95eebad88988cd8d3190c3bf05b0fb4cb70bfa3945d096491"
