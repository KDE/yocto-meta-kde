# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.12.1/src/konsole-24.12.1.tar.xz"
SRC_URI[sha256sum] = "43deca40b7fcddc340db12f08d0a63c538f1e540e9919b075a2f905e7a32cb3c"
