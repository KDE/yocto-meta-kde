# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/22.04.3/src/gwenview-22.04.3.tar.xz"
SRC_URI[sha256sum] = "8c793929f2ad3050d906e185b6753acffd9481dc619156844d681ac0ba57bc05"
