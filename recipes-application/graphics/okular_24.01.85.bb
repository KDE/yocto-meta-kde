# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.85/src/okular-24.01.85.tar.xz"
SRC_URI[sha256sum] = "121d08375238e10e32ae0b14aefa29f1c7763d79e404574732f87e49ae06253a"
