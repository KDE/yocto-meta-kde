# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.75/src/gwenview-24.01.75.tar.xz"
SRC_URI[sha256sum] = "7973b1b0e148bae5a10afc698834a8df34a6a1534d384754e2877ce464465ad6"
