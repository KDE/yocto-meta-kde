# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.08.3/src/okular-25.08.3.tar.xz"
SRC_URI[sha256sum] = "032e3de8fc546796141859691188e6f802c6de498b65cccbce60aa60d865714f"
