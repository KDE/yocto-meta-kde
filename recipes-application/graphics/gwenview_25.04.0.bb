# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.04.0/src/gwenview-25.04.0.tar.xz"
SRC_URI[sha256sum] = "ab6c75460a95c5ee3dccaec5478ed6afc9ee09b4a19f01f8e37fa1753f29ab3c"
