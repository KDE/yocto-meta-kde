# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.02.0/src/okular-24.02.0.tar.xz"
SRC_URI[sha256sum] = "fc265548f859562c54cd40587ff3c6a1c2d0f7926617951b06e6145d1f42938c"
