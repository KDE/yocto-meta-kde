# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.85/src/gwenview-24.01.85.tar.xz"
SRC_URI[sha256sum] = "8579abf32fc6d8cda99cb71974143ca228e0fac7f59c61c20716680d2066f3ef"
