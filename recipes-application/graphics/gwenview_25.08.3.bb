# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.08.3/src/gwenview-25.08.3.tar.xz"
SRC_URI[sha256sum] = "2000c42d40ee3e92ce355f82d2fddd07d27f613f71cf2e65699cfe794a76eca1"
