# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.95/src/okular-24.01.95.tar.xz"
SRC_URI[sha256sum] = "9126047e0123a358fa45a2e3b1a25630a9461acfed7ace86ec46155e5637856b"
