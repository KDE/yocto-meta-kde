# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.95/src/gwenview-24.01.95.tar.xz"
SRC_URI[sha256sum] = "ee0aee8fcc2a36e38b2f5d324476f11b508234f61ac81c9e321988249a1eddda"
