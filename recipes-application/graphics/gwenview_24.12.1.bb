# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.12.1/src/gwenview-24.12.1.tar.xz"
SRC_URI[sha256sum] = "29a8d2aced460b735a310fee22c717e652c1929a88ee999b21cd488eb19e4523"
