# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.90/src/okular-24.01.90.tar.xz"
SRC_URI[sha256sum] = "67ea6fd08e07b96a562038c65068c78762631deb96037106508c4ae3318dbfc0"
