# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/22.04.3/src/okular-22.04.3.tar.xz"
SRC_URI[sha256sum] = "7c563572e31da5c1ae23b0333c31980ca115bd859d0e181e09dd3f09f3e3570e"
