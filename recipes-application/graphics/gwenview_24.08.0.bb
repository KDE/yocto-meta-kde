# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.08.0/src/gwenview-24.08.0.tar.xz"
SRC_URI[sha256sum] = "18d10edb4f7492105a28cb1de114331b7cebf129ce626b8779e1fd75199e7476"
