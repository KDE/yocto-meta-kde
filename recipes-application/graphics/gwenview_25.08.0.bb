# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.08.0/src/gwenview-25.08.0.tar.xz"
SRC_URI[sha256sum] = "5bf1bfccedef659f4df913adddd64a2c964d39b84cf1427104bb15dbaa86f08e"
