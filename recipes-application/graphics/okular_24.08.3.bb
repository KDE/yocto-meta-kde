# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.08.3/src/okular-24.08.3.tar.xz"
SRC_URI[sha256sum] = "b398ab3302edd540c56ddd826f31d83a246e9a53c86a52e033347ab947fedc9b"
