# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.04.0/src/okular-25.04.0.tar.xz"
SRC_URI[sha256sum] = "4f41a2289e62a778c5d6e796e5846897e0161edd273ad9979b2060bb48e61b4f"
