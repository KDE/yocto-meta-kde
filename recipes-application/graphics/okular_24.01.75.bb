# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.75/src/okular-24.01.75.tar.xz"
SRC_URI[sha256sum] = "42e4a7eb1e349eadafc3d7ae46606b31afbddd44625846a3fba996ac80340152"
