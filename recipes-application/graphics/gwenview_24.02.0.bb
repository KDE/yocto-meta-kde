# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.02.0/src/gwenview-24.02.0.tar.xz"
SRC_URI[sha256sum] = "03606d3cba1520f04556ac92b2aa449f85e7daca36a637162d33c05ec42bb0b4"
