# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.08.3/src/gwenview-24.08.3.tar.xz"
SRC_URI[sha256sum] = "99a51e572adac269bf932fc90b2897376cc05e6d22f539a33c3e10c287ab7746"
