# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.08.0/src/okular-24.08.0.tar.xz"
SRC_URI[sha256sum] = "3de16e26294b3863270df1760403a676ba3d7204738bebce8a05562d932c318b"
