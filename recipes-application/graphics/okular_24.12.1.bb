# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.12.1/src/okular-24.12.1.tar.xz"
SRC_URI[sha256sum] = "bb505c1249cc598b3de328f8de0b57656fbb4445b4a313d23d948a9529e2bf20"
