# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.90/src/gwenview-24.01.90.tar.xz"
SRC_URI[sha256sum] = "7bb6e2654a10a9f3c37f5f29dc527ad138d52c49bbecdb3bc40772ba994cbc39"
