# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.80/src/okular-24.01.80.tar.xz"
SRC_URI[sha256sum] = "0227f453b7b686d07bd92118f04672cfcfac88f2d1831c66b96b83c32900a3ce"
