# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.80/src/gwenview-24.01.80.tar.xz"
SRC_URI[sha256sum] = "eaa9fe14452d860beb73f74a2930f63e5443615a6757c0f93cdb0243323f226e"
