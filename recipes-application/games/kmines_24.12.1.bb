# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.12.1/src/kmines-24.12.1.tar.xz"
SRC_URI[sha256sum] = "9696918539eb35bbe7f3669c7fa0a6d0db846f9d936e9392a4936a10e472a6c8"
