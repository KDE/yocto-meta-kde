# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.95/src/libkdegames-24.01.95.tar.xz"
SRC_URI[sha256sum] = "849e8c05f5b7ec0c87ad7c0db4122b25337f841bb9336e88acfdc70af9b4507f"
