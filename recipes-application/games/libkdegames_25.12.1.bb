# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.12.1/src/libkdegames-25.12.1.tar.xz"
SRC_URI[sha256sum] = "69290ca23cef853747ffa5b767aa05fc0397e8c31464a25828390a16eb0a8287"
