# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.08.3/src/libkdegames-25.08.3.tar.xz"
SRC_URI[sha256sum] = "46f305677fb37978c6b47bd17ab6553b572151a63299bb7b8dc718d37fb448a4"
