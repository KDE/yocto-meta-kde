# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.08.3/src/kmines-24.08.3.tar.xz"
SRC_URI[sha256sum] = "792e38c94bc10a9dc5b2055b206bd811f0d5417b7f955a4eba37ae25e69c31ba"
