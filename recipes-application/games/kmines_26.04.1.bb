# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/26.04.1/src/kmines-26.04.1.tar.xz"
SRC_URI[sha256sum] = "cf4a9826323620ae60998c2425b555a3b4d8fd8b4e1605bbaeb0ab3d99facd6a"
