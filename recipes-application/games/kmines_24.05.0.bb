# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.05.0/src/kmines-24.05.0.tar.xz"
SRC_URI[sha256sum] = "a4386ace8164e81ebb294a5587302d691086c2ab39b2bbac46320222da459441"
