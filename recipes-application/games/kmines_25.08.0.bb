# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.08.0/src/kmines-25.08.0.tar.xz"
SRC_URI[sha256sum] = "31968a4773da1004f335347b68f00ebb132dc9bd20f8f95c0d90dd94db7480f9"
