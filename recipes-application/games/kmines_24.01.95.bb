# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.95/src/kmines-24.01.95.tar.xz"
SRC_URI[sha256sum] = "2adefcf669232f8be07551d770b25b5d87b883c7b85475fa76ce09bab6333393"
