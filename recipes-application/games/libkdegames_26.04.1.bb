# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/26.04.1/src/libkdegames-26.04.1.tar.xz"
SRC_URI[sha256sum] = "31c83b61851eb7879a4b96c961cdeb32f4e131ab798122c18db59ed673f0af14"
