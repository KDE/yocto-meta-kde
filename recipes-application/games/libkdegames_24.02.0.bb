# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.02.0/src/libkdegames-24.02.0.tar.xz"
SRC_URI[sha256sum] = "3d113422dc654348b2025de5fe1de256d06a3c55be9c7b104253e25595b2e2b1"
