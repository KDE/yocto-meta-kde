# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.08.0/src/kmines-24.08.0.tar.xz"
SRC_URI[sha256sum] = "07d2955bb677ce91e301a6a18f535f206b54f246ab834d5d67c3770bfb3cec0a"
