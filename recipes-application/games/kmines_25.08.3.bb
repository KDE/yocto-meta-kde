# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.08.3/src/kmines-25.08.3.tar.xz"
SRC_URI[sha256sum] = "99f0da3cd8af9fa634a8f7d34e433bedbc4bfbda24886cd5e0bdde48e0ad4a3f"
