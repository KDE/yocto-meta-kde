# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.02.0/src/kmines-24.02.0.tar.xz"
SRC_URI[sha256sum] = "8aec9ab116f6bcdfb9428f8390b5b72ef50b883a8c3878a496e0c9ab38e7fdc5"
