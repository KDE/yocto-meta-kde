# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.04.0/src/kmines-25.04.0.tar.xz"
SRC_URI[sha256sum] = "5876a714815467ea3dd66d4b85f45fac4577689b551cda82502cbc723d308463"
