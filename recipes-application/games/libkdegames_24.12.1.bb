# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.12.1/src/libkdegames-24.12.1.tar.xz"
SRC_URI[sha256sum] = "7e845aa7cb64fef4823f3c49d59a03334313b54439d1825be2c2a5b60642fe78"
