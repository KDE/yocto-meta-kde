# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.08.0/src/libkdegames-25.08.0.tar.xz"
SRC_URI[sha256sum] = "15579343d5b06608115e8e95473b80bc91de8841b1a79584f5615a91fe57e2f7"
