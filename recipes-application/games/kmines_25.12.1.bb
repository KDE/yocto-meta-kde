# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.12.1/src/kmines-25.12.1.tar.xz"
SRC_URI[sha256sum] = "ffa7bc18515a09956d7be8f938863f424cab46f196816ee808569f7fe98da8cf"
