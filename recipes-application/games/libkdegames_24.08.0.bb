# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.08.0/src/libkdegames-24.08.0.tar.xz"
SRC_URI[sha256sum] = "22f9d42076d896a8e0a55b8e00b37974180e9f6b8606b011038db8ee6f4357c5"
