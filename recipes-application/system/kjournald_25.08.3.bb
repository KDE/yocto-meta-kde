# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.08.3/src/kjournald-25.08.3.tar.xz"
SRC_URI[sha256sum] = "09ee8081027126073f8cfebfbfbf8987e3d0b0612c1e7c525dadd3b7cc3a5f6e"
