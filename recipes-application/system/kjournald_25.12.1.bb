# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.12.1/src/kjournald-25.12.1.tar.xz"
SRC_URI[sha256sum] = "d4395cb1b96c72e0ab6d120fe1f8d553aa346e9d4306e8b414d28ea291bb26a8"
