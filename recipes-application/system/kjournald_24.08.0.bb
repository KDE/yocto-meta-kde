# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.08.0/src/kjournald-24.08.0.tar.xz"
SRC_URI[sha256sum] = "9993d2e4fc5f91ea739649d85c53197c54b0b8d49ee28cbdeb8dfb62590033c6"
