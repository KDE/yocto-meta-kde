# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/26.04.1/src/kjournald-26.04.1.tar.xz"
SRC_URI[sha256sum] = "413dac18b34896eb74bb3d3e16647bf07a0c9461f97fbe832c1abeb5f1f687a0"
