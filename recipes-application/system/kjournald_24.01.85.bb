# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.85/src/kjournald-24.01.85.tar.xz"
SRC_URI[sha256sum] = "ca87f3b5c75c15f9ded09e08fc98bf0af6c34a9f2d4aa91a4cf077c7ba332e1d"
