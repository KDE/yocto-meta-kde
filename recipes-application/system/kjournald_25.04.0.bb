# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.04.0/src/kjournald-25.04.0.tar.xz"
SRC_URI[sha256sum] = "aaaafd63a2d7fd8fd66e8a837d71809479e4a5ce20d78eb9ae9606a8453f47a7"
