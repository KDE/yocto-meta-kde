# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.90/src/kjournald-24.01.90.tar.xz"
SRC_URI[sha256sum] = "46241e0df31569d6fe12126c1ca8405de6a8084f37ef501ebb0eaea89325ca1e"
