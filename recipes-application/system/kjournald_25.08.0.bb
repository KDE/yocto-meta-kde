# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.08.0/src/kjournald-25.08.0.tar.xz"
SRC_URI[sha256sum] = "5287b36efdc7b124c81c1c6a0523357d660b5d633b7edc139480123ac74616c6"
