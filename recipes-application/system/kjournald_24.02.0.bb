# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.02.0/src/kjournald-24.02.0.tar.xz"
SRC_URI[sha256sum] = "a4f4cb343fc50fa50aec161f28ff55ce700b5c2f45a38aab26d4cd042028ba74"
