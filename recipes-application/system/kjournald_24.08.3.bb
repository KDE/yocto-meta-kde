# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.08.3/src/kjournald-24.08.3.tar.xz"
SRC_URI[sha256sum] = "af75081bdaeb1bc383401862de8db02981e7af4dc1942c97768f63fcbfc50c1b"
