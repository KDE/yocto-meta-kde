# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.80/src/kjournald-24.01.80.tar.xz"
SRC_URI[sha256sum] = "d04526c5a67fcfad9a8e5fa7f34c112694d7ab19aaa25ed511f8df1c23209282"
