# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.05.0/src/kjournald-24.05.0.tar.xz"
SRC_URI[sha256sum] = "29b5d35084be681597dda7d6d30036d36c0b973ccd6a1680ff138ab6f371f0fb"
