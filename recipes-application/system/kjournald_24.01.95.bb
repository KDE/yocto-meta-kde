# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.95/src/kjournald-24.01.95.tar.xz"
SRC_URI[sha256sum] = "bd705ebe9a9c92eb877a915492515f850ebcfd15c1405350c13ee7a1ee6b556c"
