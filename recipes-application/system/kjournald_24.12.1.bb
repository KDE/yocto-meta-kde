# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.12.1/src/kjournald-24.12.1.tar.xz"
SRC_URI[sha256sum] = "d94874c47608fe9d42d90a7e3a4480306d7f98e3e745ea718652d13e3d183ebc"
