# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.75/src/kjournald-24.01.75.tar.xz"
SRC_URI[sha256sum] = "702bd16872faf597388f5b9c416769a128663035c78a416ffc2d5445a69c479e"
