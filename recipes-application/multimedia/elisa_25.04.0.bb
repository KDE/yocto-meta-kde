# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.04.0/src/elisa-25.04.0.tar.xz"
SRC_URI[sha256sum] = "96499190370f78e07b3ad21d94d924d021dd17c4bf598b21d01bf02a2a7496af"
