# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.12.1/src/dragon-24.12.1.tar.xz"
SRC_URI[sha256sum] = "0a2de914421b4d268e137cdabe6ee6470cb52b80bffbee9d1e235524606db30f"
