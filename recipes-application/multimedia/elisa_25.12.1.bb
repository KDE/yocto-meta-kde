# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.12.1/src/elisa-25.12.1.tar.xz"
SRC_URI[sha256sum] = "76d3dcefaf3660c838d9d5751d42eb9db2f84c307c62770713194782ee001a9e"
