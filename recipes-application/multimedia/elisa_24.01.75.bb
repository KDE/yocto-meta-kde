# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.75/src/elisa-24.01.75.tar.xz"
SRC_URI[sha256sum] = "776914805696831a49670f5ba66e64d61ba01877fa527144fd5fe025b16cef9a"
