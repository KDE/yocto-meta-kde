# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.90/src/elisa-24.01.90.tar.xz"
SRC_URI[sha256sum] = "5d2857d2e09ef9f3fc770cf7f0eaa78f8db2edc849dc49dfed5b161cc31f8183"
