# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/26.04.1/src/plasma-camera-26.04.1.tar.xz"
SRC_URI[sha256sum] = "7d7ed8ef890d7ebd54ee707772cfa9aedf5b66230b55cefa117f1d5e33ec5f44"
