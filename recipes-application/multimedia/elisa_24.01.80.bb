# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.80/src/elisa-24.01.80.tar.xz"
SRC_URI[sha256sum] = "2b5e9bf25cd47c8021883a041847f9982873ecb2093056ee718102726c20e1e6"
