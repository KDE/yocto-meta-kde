# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.95/src/elisa-24.01.95.tar.xz"
SRC_URI[sha256sum] = "938bf7be4bce4efb9c7b8f9ba1865ed9d0dd08de8ea4eee45a2cda18c3522c4b"
