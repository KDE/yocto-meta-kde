# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/26.04.1/src/dragon-26.04.1.tar.xz"
SRC_URI[sha256sum] = "292a4b5b57d061d580de5be601d48ee52424b4d9b22514ad0c153679309a7262"
