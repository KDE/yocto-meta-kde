# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.08.0/src/dragon-24.08.0.tar.xz"
SRC_URI[sha256sum] = "e3e3cb8d979e99e4c8e823263ac7652e7852554fc7a17cc31bc65ea06f0ba4a0"
