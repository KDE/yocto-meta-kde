# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.04.0/src/dragon-25.04.0.tar.xz"
SRC_URI[sha256sum] = "d21f511cbb3057714944aab2b4cda49c8aa6f3534b4ea71bec7e79904d0c931e"
