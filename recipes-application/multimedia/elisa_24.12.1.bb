# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.12.1/src/elisa-24.12.1.tar.xz"
SRC_URI[sha256sum] = "458f3944b8a28d5c60e979770c71c21fec9634e814c3123d8a5ae21365b0c229"
