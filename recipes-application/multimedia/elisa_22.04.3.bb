# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/22.04.3/src/elisa-22.04.3.tar.xz"
SRC_URI[sha256sum] = "68c64892712446eb4a75b903d8903514f4b2b30d1d1d3a1b34ceececbd3a50ec"
