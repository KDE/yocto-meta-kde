# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.05.0/src/elisa-24.05.0.tar.xz"
SRC_URI[sha256sum] = "2d377125cb3432d7a220b0e907133348e67d251c8cda60c25e04bba0d24e8df7"
