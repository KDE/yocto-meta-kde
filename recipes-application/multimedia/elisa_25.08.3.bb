# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.08.3/src/elisa-25.08.3.tar.xz"
SRC_URI[sha256sum] = "63674bbd058a518d740bd9880d65a9af6a816fc33fb904cc1f0c0c248447dd13"
