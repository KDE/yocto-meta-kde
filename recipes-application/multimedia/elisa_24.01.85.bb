# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.85/src/elisa-24.01.85.tar.xz"
SRC_URI[sha256sum] = "c259d3cca112fae99cc5154e2638119e0bb48a08e79575561e3c55a2e837d529"
