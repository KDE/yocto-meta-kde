# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.95/src/dragon-24.01.95.tar.xz"
SRC_URI[sha256sum] = "923756f90871ceb9e5744f5c73a55d72a117ff1e69f3eee826f3514f58643466"
