# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.08.0/src/elisa-25.08.0.tar.xz"
SRC_URI[sha256sum] = "76029c54e927873039c3c282ada787a78f1d0d6dbc8fa9bd2e819aeec5df2d5c"
