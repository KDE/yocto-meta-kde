# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.90/src/dragon-24.01.90.tar.xz"
SRC_URI[sha256sum] = "114084f83e99913b3c9d87f40f7e9234f1ecfdc8c2dbf663d119c1dda338d893"
