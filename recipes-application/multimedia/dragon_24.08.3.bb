# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.08.3/src/dragon-24.08.3.tar.xz"
SRC_URI[sha256sum] = "24af10ad04f11b368fbbb90a2ee7fccbac89f0166c54b4bb0b55940d6cb76b4c"
