# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.05.0/src/dragon-24.05.0.tar.xz"
SRC_URI[sha256sum] = "b4e821104d3bb63bfbd44f6dd37141b423e64ce5db2d4e95915214860150df8b"
