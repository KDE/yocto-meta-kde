# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.12.1/src/dragon-25.12.1.tar.xz"
SRC_URI[sha256sum] = "f7f751a4b6cbf3f1b02afc215ecfea31d0cbeac4c7e8add6e50a0cbeafff0948"
