# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.08.3/src/elisa-24.08.3.tar.xz"
SRC_URI[sha256sum] = "9b6aebf36e05fc568213f5437a0431a84a595f4ba89189bb5e0541d51eccdbd7"
