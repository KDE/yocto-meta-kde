# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.12.1/src/kongress-25.12.1.tar.xz"
SRC_URI[sha256sum] = "7ce47c65b17922c9124c4a5ee42e5c36a51448984323fd4dd7d1f3936076acd9"
