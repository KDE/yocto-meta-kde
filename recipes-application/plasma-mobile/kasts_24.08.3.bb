# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.08.3/src/kasts-24.08.3.tar.xz"
SRC_URI[sha256sum] = "1853a1f37872836e2596f440f0533a99e2d8cad693b1ad5f252266e7a6acfc76"
