# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.08.3/src/kweather-24.08.3.tar.xz"
SRC_URI[sha256sum] = "37a0a09d4953cf4c279d1710ecae73762166d8ed54b8bb801cc1770497b5bd4d"
