# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.08.0/src/kweather-24.08.0.tar.xz"
SRC_URI[sha256sum] = "6ab41961bf57bfeb42b679167f3a42e258af264b919654e70f780b814d1e0354"
