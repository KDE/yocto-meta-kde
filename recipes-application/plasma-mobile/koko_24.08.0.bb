# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.08.0/src/koko-24.08.0.tar.xz"
SRC_URI[sha256sum] = "7548db173edbffcb42fef693d8d0966dbfc4ef8e649a85da5c00cca8cf4c9855"
