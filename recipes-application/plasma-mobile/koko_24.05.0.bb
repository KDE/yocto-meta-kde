# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI += "https://download.kde.org/stable/release-service/24.05.0/src/koko-24.05.0.tar.xz"
SRC_URI[sha256sum] = "80379b51d1c3eb5becde1d03263c24fcae98d4d2e88b8b6d057ca9cfeb10a9b9"
