# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.08.3/src/qmlkonsole-25.08.3.tar.xz"
SRC_URI[sha256sum] = "4850fa949782db331cb4aa85cf67d727edd806b7771abe82d4a7d56a0ebefc4d"
