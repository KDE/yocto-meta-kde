# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.12.1/src/kclock-25.12.1.tar.xz"
SRC_URI[sha256sum] = "e0367d9a089d262844c4e925dd7a1b39057e2584b786fc640a603edf2e723335"
