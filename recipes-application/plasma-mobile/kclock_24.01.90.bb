# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.90/src/kclock-24.01.90.tar.xz"
SRC_URI[sha256sum] = "cc9e9320f046d10717c491e82dab5fd86d37f0119c426c49053a7cfa935ac4ca"
