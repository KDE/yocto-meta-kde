# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.08.3/src/kclock-24.08.3.tar.xz"
SRC_URI[sha256sum] = "64675186861b20d2a171b305ccd5fdc9a61171cd254dbad9e0ed953fce8e2c9f"
