# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.12.1/src/alligator-24.12.1.tar.xz"
SRC_URI[sha256sum] = "2a3e0c3d0819019388aebddbcc54cbc053a4354f7f833621be9c8b269d8cf295"
