# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.08.0/src/alligator-24.08.0.tar.xz"
SRC_URI[sha256sum] = "8152a6b88ffeeca365c038e062ed78e65a97ddb96ab9988975d784e59dce350d"
