# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.12.1/src/qmlkonsole-25.12.1.tar.xz"
SRC_URI[sha256sum] = "f7b101dbbaafaca35a2414dde762a2c0e7408e1899729b1e89ca9519475e7f0b"
