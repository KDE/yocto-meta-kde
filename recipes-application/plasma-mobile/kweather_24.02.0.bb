# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.02.0/src/kweather-24.02.0.tar.xz"
SRC_URI[sha256sum] = "86beab7132e3d0748b7c402902ed0925b573d79b4c63a4a1941e58898468ccaf"
