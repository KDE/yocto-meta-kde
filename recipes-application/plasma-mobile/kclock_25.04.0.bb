# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.04.0/src/kclock-25.04.0.tar.xz"
SRC_URI[sha256sum] = "24895305b1576d80cb65347353eb0a12af287f98efcc46598f1e90cd871a7ccd"
