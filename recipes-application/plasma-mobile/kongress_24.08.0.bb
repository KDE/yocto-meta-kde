# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.08.0/src/kongress-24.08.0.tar.xz"
SRC_URI[sha256sum] = "941d64669700ffc8b1434b54fe3fbbf14d6d8ee96d5d0d69af50e566252a3436"
