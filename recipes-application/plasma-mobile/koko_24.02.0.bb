# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.02.0/src/koko-24.02.0.tar.xz"
SRC_URI[sha256sum] = "6f9d5e3ced972cb3c1f541629e71602ce256cb6a26c33407ef16fe4020cbf1da"
