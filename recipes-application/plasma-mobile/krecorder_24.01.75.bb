# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.75/src/krecorder-24.01.75.tar.xz"
SRC_URI[sha256sum] = "f1105e3eccace3a1b4d1a48add7cef45c45dfcb9ec06cf35dc6b9a6abc13b14f"
