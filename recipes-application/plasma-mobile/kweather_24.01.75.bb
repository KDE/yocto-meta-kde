# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.75/src/kweather-24.01.75.tar.xz"
SRC_URI[sha256sum] = "650c8627d5870143223642f026d0463c0926d8fa862999ee3161e63c507afcc4"
