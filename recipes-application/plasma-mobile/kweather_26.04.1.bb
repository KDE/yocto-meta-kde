# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/26.04.1/src/kweather-26.04.1.tar.xz"
SRC_URI[sha256sum] = "c5227cc66ec53093bc356f21ea57392e946258fdb1527cee9c311066496f5389"
