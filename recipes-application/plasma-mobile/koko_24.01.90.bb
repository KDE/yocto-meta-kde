# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.90/src/koko-24.01.90.tar.xz"
SRC_URI[sha256sum] = "0d6504722c2f34f8c04a32123ec36e304d8ab6a0573a2f7de49c126fe3a35fbc"
