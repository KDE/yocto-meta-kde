# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/26.04.1/src/kongress-26.04.1.tar.xz"
SRC_URI[sha256sum] = "341341514a02b315ff90590b8eb9569edcfc1f1c8a29c64a31b86bb7a5171e37"
