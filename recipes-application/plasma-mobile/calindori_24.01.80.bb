# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.80/src/calindori-24.01.80.tar.xz"
SRC_URI[sha256sum] = "f5acc46632c66842dd39716fdd040cbd7e427756a877c58034529a912c476f30"
