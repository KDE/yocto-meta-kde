# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.08.3/src/ktrip-24.08.3.tar.xz"
SRC_URI[sha256sum] = "b7f86b60e330a92c480423f12587daaf0d3fb6a3ca53a1c56bb5468a832154b6"
