# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.85/src/koko-24.01.85.tar.xz"
SRC_URI[sha256sum] = "e1426f7c04a8db5b14945de0b17c2cd4124382a093a47e49d075a3b6e8942d10"
