# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRCREV = "603bbbdd04142b4cd53ea78d8ef94a4390285a21"
SRC_URI = "git://commits.kde.org/${BPN};nobranch=1;protocol=https"
S = "${WORKDIR}/git"
