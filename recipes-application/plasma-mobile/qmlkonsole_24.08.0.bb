# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.08.0/src/qmlkonsole-24.08.0.tar.xz"
SRC_URI[sha256sum] = "848806e00704d44946b319a449eba26c1a790aa288139fb7e79a3048090a740c"
