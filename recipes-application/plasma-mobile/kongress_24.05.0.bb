# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.05.0/src/kongress-24.05.0.tar.xz"
SRC_URI[sha256sum] = "3c68875d9a2386218fd214281c53e2f17ac277d467ec3be70095954e1ebe88c1"
