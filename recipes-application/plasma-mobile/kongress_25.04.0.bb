# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.04.0/src/kongress-25.04.0.tar.xz"
SRC_URI[sha256sum] = "5c38f856d9bf81638b76412b77740a4716b65f2a8798f56ce50e6c03b5c55470"
