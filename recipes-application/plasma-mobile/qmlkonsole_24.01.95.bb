# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.95/src/qmlkonsole-24.01.95.tar.xz"
SRC_URI[sha256sum] = "cc4f6e32892b0503b86e76bb52585b44c30f147b73f60f7e1342bcd8d7853b63"
