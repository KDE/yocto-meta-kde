# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/26.04.1/src/plasma-settings-26.04.1.tar.xz"
SRC_URI[sha256sum] = "795d2334290ab76e6393daa1dc7ba19f6927c9e9b8578904a9de9eb91b9636b5"
