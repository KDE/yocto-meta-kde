# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.75/src/calindori-24.01.75.tar.xz"
SRC_URI[sha256sum] = "e19354c516e3383eea36049226c95bdc938c2896a6249ca86d463cdcf0f8b95c"
