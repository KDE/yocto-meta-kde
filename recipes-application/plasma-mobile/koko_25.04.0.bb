# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.04.0/src/koko-25.04.0.tar.xz"
SRC_URI[sha256sum] = "9b368640c5a682f6f68cc85e7f8edba139a34b98b75976e952a7a5f93753d8a3"
