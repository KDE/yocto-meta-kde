# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.85/src/kweather-24.01.85.tar.xz"
SRC_URI[sha256sum] = "deae738bd801a22283c78b40b2713e51b835675d6a616fc6e7a3c3dc25fabee5"
