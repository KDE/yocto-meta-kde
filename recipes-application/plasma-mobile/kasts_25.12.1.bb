# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.12.1/src/kasts-25.12.1.tar.xz"
SRC_URI[sha256sum] = "e8b7a024e113b9047933c4e502fbfb0f5a814e243ea92302c29abd6626968662"
