# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.75/src/koko-24.01.75.tar.xz"
SRC_URI[sha256sum] = "b329f14c8c5117b00aaa89706c33c9232c8b1bf3f98d154081bc1a8f4143848d"
