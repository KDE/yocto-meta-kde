# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.95/src/ktrip-24.01.95.tar.xz"
SRC_URI[sha256sum] = "8afb9b3d3f1e716d3a47427a8b7be7423a875eb595faa80bbb835aea48aa6e05"
