# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.05.0/src/kasts-24.05.0.tar.xz"
SRC_URI[sha256sum] = "fa1ecf184c71acb88b1983d6b1c72d812e2cf3c937ccc79fc885de97cb8b6082"
