# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.08.3/src/kongress-25.08.3.tar.xz"
SRC_URI[sha256sum] = "9d7f5e78953553a67f1803dee7b0c6e3182686dc173c7654f23f3ac2dc5555db"
