# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.85/src/calindori-24.01.85.tar.xz"
SRC_URI[sha256sum] = "851184799e7fb79e3932b551e8fc962757b26e1737dc62d45c5725072df03905"
