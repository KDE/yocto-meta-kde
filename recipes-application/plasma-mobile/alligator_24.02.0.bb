# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.02.0/src/alligator-24.02.0.tar.xz"
SRC_URI[sha256sum] = "ea707eb94082076558b44c6b63a7593a45e6dee3e7bf401a2ae6b231997c74d8"
