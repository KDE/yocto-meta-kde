# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.05.0/src/qmlkonsole-24.05.0.tar.xz"
SRC_URI[sha256sum] = "4e3145fddb2df121793a8f52c35590a968759f611a798d8f44a9dda01d1d4242"
