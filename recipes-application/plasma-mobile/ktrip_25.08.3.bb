# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.08.3/src/ktrip-25.08.3.tar.xz"
SRC_URI[sha256sum] = "ebb5d68338e1291f343456917c1d277de957256463bf7f743005d452750220bf"
