# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.80/src/kclock-24.01.80.tar.xz"
SRC_URI[sha256sum] = "644f8ed3f9947133e01ce9114872dd94e34ee5a84544b2786ebb3319062825b2"
