# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.12.1/src/alligator-25.12.1.tar.xz"
SRC_URI[sha256sum] = "2158ac2625b13efc43f06aa46aad2a75e9c4a92e416d825018fc9b8059dda35f"
