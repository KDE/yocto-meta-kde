# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.08.0/src/kasts-25.08.0.tar.xz"
SRC_URI[sha256sum] = "c7cb5d3ce480d97b96402d8f9dcfc40c0465a4e1cfe3513fb7ccef78e5eb275c"
