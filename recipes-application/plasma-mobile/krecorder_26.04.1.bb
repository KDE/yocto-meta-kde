# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/26.04.1/src/krecorder-26.04.1.tar.xz"
SRC_URI[sha256sum] = "c6560619977ff00ddff7684bb7b70c743aa015e88b3b4dfd752314aee8ca2ece"
