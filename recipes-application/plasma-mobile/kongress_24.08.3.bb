# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.08.3/src/kongress-24.08.3.tar.xz"
SRC_URI[sha256sum] = "47f445e7f91a30bf6f5c76820fceb8c3549062b4fdffc2a575e9e6b0b15d63e2"
