# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/26.04.1/src/ktrip-26.04.1.tar.xz"
SRC_URI[sha256sum] = "80a51468c09c21b11c083d43afb695655c59ba0c4ebd996f48330b0cbaf2724c"
