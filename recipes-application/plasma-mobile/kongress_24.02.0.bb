# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.02.0/src/kongress-24.02.0.tar.xz"
SRC_URI[sha256sum] = "b7842c0480bc05bdeae416721bae2abf15b555ce67174d996705e4a80bf224d9"
