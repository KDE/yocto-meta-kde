# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.04.0/src/qmlkonsole-25.04.0.tar.xz"
SRC_URI[sha256sum] = "d3c70c4ead5960cc70c3725ae3e3d2f262c742d10763b9bb1fd2d3c7d16d4274"
