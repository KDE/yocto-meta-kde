# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.85/src/krecorder-24.01.85.tar.xz"
SRC_URI[sha256sum] = "79fe4986b414967416094791f2592fe7405af3b8afb63533532c25c0a9170731"
