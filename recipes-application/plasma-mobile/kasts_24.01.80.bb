# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.80/src/kasts-24.01.80.tar.xz"
SRC_URI[sha256sum] = "54cef5bfb2931a2142c1040cf28805054fa085d551581c7adcb3157fd988d6ef"
