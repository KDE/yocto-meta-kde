# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.12.1/src/krecorder-25.12.1.tar.xz"
SRC_URI[sha256sum] = "e3d86e98f7b85d4eacabeb0adcd7b67d5935dafc590b88d16986a67082b2b3e5"
