# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.85/src/kclock-24.01.85.tar.xz"
SRC_URI[sha256sum] = "d28ef390381c468c0f96063f8793fcd58504e6e1da2727ce3a25c03fc72a9159"
