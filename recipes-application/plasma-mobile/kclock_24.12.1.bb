# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.12.1/src/kclock-24.12.1.tar.xz"
SRC_URI[sha256sum] = "79d2d725d121e6cea36fd094ba850822bcb475ee4208e6f716bf9b29a75eacbb"
