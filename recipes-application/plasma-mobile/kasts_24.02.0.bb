# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.02.0/src/kasts-24.02.0.tar.xz"
SRC_URI[sha256sum] = "e21dbe9096a46fcedf93b93e3a57bb1d88a1939cc05142e4d9c90dd97087b9e7"
