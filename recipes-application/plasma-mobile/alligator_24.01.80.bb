# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.80/src/alligator-24.01.80.tar.xz"
SRC_URI[sha256sum] = "1597e73729ff04cf55779ddca26f70b9d25ee695803549e1c0ac4aaedadfb60d"
