# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.02.0/src/krecorder-24.02.0.tar.xz"
SRC_URI[sha256sum] = "01e9626b917828e7ddac9b020891cb0fa039d7d464a622fcb983dfe3bf02755d"
