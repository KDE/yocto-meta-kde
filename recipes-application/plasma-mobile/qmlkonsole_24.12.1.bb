# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.12.1/src/qmlkonsole-24.12.1.tar.xz"
SRC_URI[sha256sum] = "aacd7154285a30c8443e17432e4a0e3de38134eeb2a12945d9383f0ba6f2fabe"
