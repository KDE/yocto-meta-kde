# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.12.1/src/ktrip-24.12.1.tar.xz"
SRC_URI[sha256sum] = "3b20572806e7167e089becf5eb4de31ba973b843a1d4def3fc36836f8b24189b"
