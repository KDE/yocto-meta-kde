# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.90/src/alligator-24.01.90.tar.xz"
SRC_URI[sha256sum] = "05c67ed1e41bbd39ef6f5aa99bf0d52d065fe012c52ef17206a0a693a2cf95f5"
