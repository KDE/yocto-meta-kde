# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.08.3/src/qmlkonsole-24.08.3.tar.xz"
SRC_URI[sha256sum] = "b5e0dd41a485d672908eaff62ca1ce7dfe3112fa218dfffacf5f8aef64dc802a"
