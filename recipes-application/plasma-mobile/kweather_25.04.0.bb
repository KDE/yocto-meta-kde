# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.04.0/src/kweather-25.04.0.tar.xz"
SRC_URI[sha256sum] = "dfdfb8d99186b0311f40eaeff780567f45121aae0e71cfb674a4adcd06a90162"
