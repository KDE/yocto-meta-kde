# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.04.0/src/kasts-25.04.0.tar.xz"
SRC_URI[sha256sum] = "49e0983cf70d17e1771255c0321d74602c54e28cf7d14d3143286d9a22c898fe"
