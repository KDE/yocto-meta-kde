# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.08.3/src/koko-24.08.3.tar.xz"
SRC_URI[sha256sum] = "7faa6c783d715514010404e6618ff54930968e5221f9c43a2d2fff569427e0ac"
