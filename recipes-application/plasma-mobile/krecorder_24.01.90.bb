# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.90/src/krecorder-24.01.90.tar.xz"
SRC_URI[sha256sum] = "e8998955cc6485daea1895919a9f81898ffadd776308c84aae05260d69fbf67c"
