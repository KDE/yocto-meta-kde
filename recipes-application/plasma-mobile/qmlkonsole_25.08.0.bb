# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.08.0/src/qmlkonsole-25.08.0.tar.xz"
SRC_URI[sha256sum] = "06cb9155536079d40a68cf8e8ac52dc8e686dfb68e9fb2f078c858c1465ca424"
