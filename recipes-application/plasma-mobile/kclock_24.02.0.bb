# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.02.0/src/kclock-24.02.0.tar.xz"
SRC_URI[sha256sum] = "5b0a19ba853067a26176929bc65395031de930555566062d19a2ee14f8886246"
