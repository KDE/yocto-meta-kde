# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.75/src/alligator-24.01.75.tar.xz"
SRC_URI[sha256sum] = "10bc1e216b3bb5d423af23559c4d3a02eaf8d0d3856e5356ab9a3c12df7d6c44"
