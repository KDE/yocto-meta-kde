# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.08.0/src/krecorder-24.08.0.tar.xz"
SRC_URI[sha256sum] = "2c2a43f69cd7bc68f584b215fbe3a6065e705d1f0941986910408bab060e65af"
