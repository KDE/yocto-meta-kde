# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.75/src/ktrip-24.01.75.tar.xz"
SRC_URI[sha256sum] = "4a9007c6aca61d79a61fdef33733603ac54bac83e959847f34b25123b5136447"
