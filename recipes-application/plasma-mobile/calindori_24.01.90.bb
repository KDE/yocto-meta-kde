# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.90/src/calindori-24.01.90.tar.xz"
SRC_URI[sha256sum] = "9394e28ed8a0c1eaf9354a01d143406b263acf3520c926082e51c09777c610b9"
