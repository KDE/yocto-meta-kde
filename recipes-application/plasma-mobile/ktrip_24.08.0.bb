# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.08.0/src/ktrip-24.08.0.tar.xz"
SRC_URI[sha256sum] = "61ae3597f67fec71ad798f87ecec0da90a66d68df32b76c551f786c87f204091"
