# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.95/src/kongress-24.01.95.tar.xz"
SRC_URI[sha256sum] = "e44a257880fb4b189f9374b9217b0ec9bb08f7c7511b405c8595acd8bab6113e"
