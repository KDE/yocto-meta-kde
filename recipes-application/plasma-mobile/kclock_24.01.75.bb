# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.75/src/kclock-24.01.75.tar.xz"
SRC_URI[sha256sum] = "52093649bde6a60996ef3ecda90a889ec769beaa3645a309b9ac19f34ae0ad13"
