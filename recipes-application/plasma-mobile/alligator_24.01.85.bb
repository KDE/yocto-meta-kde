# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.85/src/alligator-24.01.85.tar.xz"
SRC_URI[sha256sum] = "10bf74a06f89f041fab515b9f583e150d44785bb4222202b21aef10a22dcc5e0"
