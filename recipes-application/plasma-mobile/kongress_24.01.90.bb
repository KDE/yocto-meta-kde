# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.90/src/kongress-24.01.90.tar.xz"
SRC_URI[sha256sum] = "9b0021d5a8a4edfa009fcda80b38831f65a2fcf9c0d07da632d188fccb1c2cb9"
