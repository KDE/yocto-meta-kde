# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.95/src/kweather-24.01.95.tar.xz"
SRC_URI[sha256sum] = "bdbaca80ca3cd79a60e7ab5c73029ede5f1fd93776ef6ae81f8dc8ce4b8ae39a"
