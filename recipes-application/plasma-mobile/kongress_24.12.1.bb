# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.12.1/src/kongress-24.12.1.tar.xz"
SRC_URI[sha256sum] = "db3eaf4adbf0d68beaa65031a02b2c8f9cafcb9dfbf565938e963e9e46a6b01b"
