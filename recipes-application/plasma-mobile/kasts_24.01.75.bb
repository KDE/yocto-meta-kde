# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.75/src/kasts-24.01.75.tar.xz"
SRC_URI[sha256sum] = "7932a8c621b59206628625c424b126ff654e6a430b579fc583c0c9c251be9fe0"
