# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.95/src/calindori-24.01.95.tar.xz"
SRC_URI[sha256sum] = "5f1c8b8ca772fc48319f546c5225d05c04ed453cded466d6ba4aa1bc463d9766"
