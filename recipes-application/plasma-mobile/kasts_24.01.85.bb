# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.85/src/kasts-24.01.85.tar.xz"
SRC_URI[sha256sum] = "4df01f86675a102902a8f287a666caaee7443fc382ebfe4d1e390c8499f7c170"
