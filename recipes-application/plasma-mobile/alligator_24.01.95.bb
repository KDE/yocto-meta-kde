# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.95/src/alligator-24.01.95.tar.xz"
SRC_URI[sha256sum] = "3f9681ce0da5bcb9e22ba6e4e9a6ecd9c4258b166d68136af4c1a769f702d866"
