# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.05.0/src/krecorder-24.05.0.tar.xz"
SRC_URI[sha256sum] = "39352f8aa380abaef5ce93cf9c3b4ef3e35dffa69ceb824091e42d8bf7138f32"
