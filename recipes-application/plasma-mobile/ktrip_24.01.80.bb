# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.80/src/ktrip-24.01.80.tar.xz"
SRC_URI[sha256sum] = "d227c4becfc2e53dbf46e72f45a37dffd03ed05eea54f2a7298eef935d3a3554"
