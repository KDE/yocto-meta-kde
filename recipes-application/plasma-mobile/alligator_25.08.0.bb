# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.08.0/src/alligator-25.08.0.tar.xz"
SRC_URI[sha256sum] = "bb39c244f7e26d06d342515a8e69888fbe7a5ea3b7c224ff1f0a0c2718a32d8c"
