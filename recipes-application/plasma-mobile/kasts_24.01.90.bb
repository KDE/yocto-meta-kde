# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.90/src/kasts-24.01.90.tar.xz"
SRC_URI[sha256sum] = "339245ba7d265e254465c6c61690dd286da711bfd8124324cf5129d4a9c21faf"
