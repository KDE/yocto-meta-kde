# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.95/src/kclock-24.01.95.tar.xz"
SRC_URI[sha256sum] = "edd0ecf55550e4554d1a84e8dda2b279aa669a0edd5e323bfb4a7ae411a5a2f9"
