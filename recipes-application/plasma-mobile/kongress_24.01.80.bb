# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.80/src/kongress-24.01.80.tar.xz"
SRC_URI[sha256sum] = "2d11406f2657ddc01e07b141b2434fcae4132774350b3ca6bdbacd8a1ee6a7d7"
