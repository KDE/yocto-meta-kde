# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.04.0/src/krecorder-25.04.0.tar.xz"
SRC_URI[sha256sum] = "6f9f741d1a2d9a95f6cbbeb4ed5683baaa6125dc000db0fa45cf98c0c697604a"
