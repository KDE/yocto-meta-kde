# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.95/src/kasts-24.01.95.tar.xz"
SRC_URI[sha256sum] = "33443a399d4417ecaabd9f2948fc58678b9bf45bd6adba7121b4de648f937a9c"
