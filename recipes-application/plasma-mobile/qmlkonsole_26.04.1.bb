# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/26.04.1/src/qmlkonsole-26.04.1.tar.xz"
SRC_URI[sha256sum] = "99bf4503a41ffee2dbcc6e3b6bddeb257cc91d44a23f09aa33cc2ed4c0b7865e"
