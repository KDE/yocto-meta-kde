# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.02.0/src/qmlkonsole-24.02.0.tar.xz"
SRC_URI[sha256sum] = "77309eed9bf4b7a1bf3fc26b02253f0b9db5dae596c4334b168884422aaa8a06"
