# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.85/src/qmlkonsole-24.01.85.tar.xz"
SRC_URI[sha256sum] = "ac0a15101a9bff1227dbf424fdcc40f1fdc87b67065acf45115bc7311379a6b2"
