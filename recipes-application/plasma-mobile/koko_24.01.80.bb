# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.80/src/koko-24.01.80.tar.xz"
SRC_URI[sha256sum] = "5cd08ded83efce7e9c8427086dc9796a82abddf30e61ce888e182e254c3d5ca8"
