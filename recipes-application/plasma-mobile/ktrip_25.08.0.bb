# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.08.0/src/ktrip-25.08.0.tar.xz"
SRC_URI[sha256sum] = "bfcadd7101809c0ae371e0050485c669ad1636440dd22fc352db895a949460b7"
