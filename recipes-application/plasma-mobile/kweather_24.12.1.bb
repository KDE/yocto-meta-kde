# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.12.1/src/kweather-24.12.1.tar.xz"
SRC_URI[sha256sum] = "bf1b709cf889fa7d133f387fb09f945dacd15addd40f0537bd10c4db4ad717da"
