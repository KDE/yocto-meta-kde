# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.85/src/ktrip-24.01.85.tar.xz"
SRC_URI[sha256sum] = "bae586cc9eacbedaa181c9297cf92f51c265af35715f9b8b6b56f98c4475b9a7"
