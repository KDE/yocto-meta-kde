# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.12.1/src/ktrip-25.12.1.tar.xz"
SRC_URI[sha256sum] = "70d4c8cbfd12db5a8a2e7967fb05359d809721c5ef3a06c36d0e7be57a46ba58"
