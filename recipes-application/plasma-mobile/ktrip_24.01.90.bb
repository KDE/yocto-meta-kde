# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.90/src/ktrip-24.01.90.tar.xz"
SRC_URI[sha256sum] = "04aa4023b38a1f17ab4a042807fdb15858be772edc24d6a69ea1a55c11d937be"
