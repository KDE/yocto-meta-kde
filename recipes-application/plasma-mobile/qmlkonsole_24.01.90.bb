# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.90/src/qmlkonsole-24.01.90.tar.xz"
SRC_URI[sha256sum] = "6a8df173ad93011d009c84f66807d45a460309d433bc3b534dee1dfb1f42ed49"
