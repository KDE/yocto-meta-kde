# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.08.0/src/kongress-25.08.0.tar.xz"
SRC_URI[sha256sum] = "0b72a9b8b885f2730b74fb4e0bc9ce2812d0b92d1e6ea089d74c82db44922637"
