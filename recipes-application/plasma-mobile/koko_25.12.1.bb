# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.12.1/src/koko-25.12.1.tar.xz"
SRC_URI[sha256sum] = "0c1e7cfbd58f0f5e467f128c891a5f953176c899918d57771b83b55f74dff5bb"
