# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.90/src/kweather-24.01.90.tar.xz"
SRC_URI[sha256sum] = "b3780f5261220f55ea57b29da77e3f464cb61ec984b82e12c4e3c357f5537da5"
