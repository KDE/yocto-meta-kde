# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.12.1/src/kweather-25.12.1.tar.xz"
SRC_URI[sha256sum] = "1c03976929061996d54dac5346d0774acc285627173e10e0a80c6a78ed52e697"
