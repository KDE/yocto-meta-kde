# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.02.0/src/ktrip-24.02.0.tar.xz"
SRC_URI[sha256sum] = "44f26fe26f2bfa3342497051cb04bf34210aa7efed8615dac455bb4f39d7fbbb"
