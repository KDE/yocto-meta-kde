# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.08.3/src/alligator-25.08.3.tar.xz"
SRC_URI[sha256sum] = "3806d7aa813f8ebc34eb53cf7a50e069739b49b691d58b7c9063805c34dcb8fa"
