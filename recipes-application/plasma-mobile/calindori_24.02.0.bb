# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.02.0/src/calindori-24.02.0.tar.xz"
SRC_URI[sha256sum] = "ba65760da355e7a725091c3ddee395755b51a56fc937495d6df8f5fc14f3de93"
