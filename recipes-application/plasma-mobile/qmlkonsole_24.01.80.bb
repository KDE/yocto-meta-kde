# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.80/src/qmlkonsole-24.01.80.tar.xz"
SRC_URI[sha256sum] = "14fdfeb44abfca0c4f8993eb1953b5c9d1a80dca21ef5230956f6336efde18b4"
