# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.08.3/src/krecorder-24.08.3.tar.xz"
SRC_URI[sha256sum] = "53697791693bc2fa7381b27a2a7060a0b90f724b052b39d6cb44b9953cfed378"
