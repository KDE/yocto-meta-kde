# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.12.1/src/koko-24.12.1.tar.xz"
SRC_URI[sha256sum] = "0548b79852eeea2342aad275eb3e246547bd34325fb2b68e91131f401a48fc8e"
