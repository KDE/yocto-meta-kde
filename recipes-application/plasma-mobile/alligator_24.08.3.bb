# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.08.3/src/alligator-24.08.3.tar.xz"
SRC_URI[sha256sum] = "543f17a4a26042379490809b26a93dddbe7a924f733cacf391bd8eb1b5ee8ab0"
