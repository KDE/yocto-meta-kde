# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.08.0/src/kclock-25.08.0.tar.xz"
SRC_URI[sha256sum] = "b0fe8c3a4c423c5ca40d9daef287f1d84498ea6b2acf66af55bdbd77e077f896"
