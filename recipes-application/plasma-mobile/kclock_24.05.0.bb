# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.05.0/src/kclock-24.05.0.tar.xz"
SRC_URI[sha256sum] = "96debe05eb4118ba4a8064e4357c75d54716ad0d7e4bb6b96b291beadc8eb9c6"
