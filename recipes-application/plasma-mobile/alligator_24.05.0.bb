# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.05.0/src/alligator-24.05.0.tar.xz"
SRC_URI[sha256sum] = "47389194d41f195e1b23d8b0ab88315f3d2071e2352962659dd3326cf7f3c5e5"
