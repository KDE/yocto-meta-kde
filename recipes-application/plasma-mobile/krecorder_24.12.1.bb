# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.12.1/src/krecorder-24.12.1.tar.xz"
SRC_URI[sha256sum] = "2cbea23349aeb141a6190d8cd0f30ce8b4c6d52c38b533a56c688f477b2f755e"
