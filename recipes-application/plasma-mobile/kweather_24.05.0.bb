# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.05.0/src/kweather-24.05.0.tar.xz"
SRC_URI[sha256sum] = "faff3add4005d04c338847ae9b7a1bc2e5c6d5f45b6f5a96ec806da91b9e4bbe"
