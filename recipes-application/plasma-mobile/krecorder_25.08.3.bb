# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.08.3/src/krecorder-25.08.3.tar.xz"
SRC_URI[sha256sum] = "3278fbdda7fbc440b6f922b644ac8d32dcc63d4d443b779cc2cb08317a263361"
