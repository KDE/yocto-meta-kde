# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/26.04.1/src/alligator-26.04.1.tar.xz"
SRC_URI[sha256sum] = "75fd1bea0a1b8a905614db3d7f17c072c0246249f5158ddc85b7c74b54c2b559"
