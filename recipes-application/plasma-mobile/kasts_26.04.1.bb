# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/26.04.1/src/kasts-26.04.1.tar.xz"
SRC_URI[sha256sum] = "a59741617f1e708146c5e344206ffac0051255c18031f09631886804fdb487c4"
