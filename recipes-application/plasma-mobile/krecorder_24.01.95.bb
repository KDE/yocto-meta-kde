# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.95/src/krecorder-24.01.95.tar.xz"
SRC_URI[sha256sum] = "862789433487975efd3ba10da85a3f0aa6a2f692d4f24a9cddb2401d48f3e99b"
