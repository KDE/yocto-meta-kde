# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.08.3/src/koko-25.08.3.tar.xz"
SRC_URI[sha256sum] = "cd67043b969c9469d9e9c1067cf42c2ea3e22e0227abef3a77620d8fcd259757"
