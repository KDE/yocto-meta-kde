# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.08.0/src/kweather-25.08.0.tar.xz"
SRC_URI[sha256sum] = "acd8d383abc97323a08283f5c34511d05a06b7019320d024968a01ccf6fe2106"
