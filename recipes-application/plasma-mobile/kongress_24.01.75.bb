# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.75/src/kongress-24.01.75.tar.xz"
SRC_URI[sha256sum] = "2323e1951b2cd01795ac8144ae37e1c8a78ac38acc80df4b47b20e5a22247546"
