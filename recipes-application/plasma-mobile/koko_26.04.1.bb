# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/26.04.1/src/koko-26.04.1.tar.xz"
SRC_URI[sha256sum] = "70810148e2f86325017ea6c6446d17dfb960fd8ce66b5d9f9ec0e7b8d142d954"
