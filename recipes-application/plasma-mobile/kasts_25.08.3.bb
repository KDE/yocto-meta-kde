# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.08.3/src/kasts-25.08.3.tar.xz"
SRC_URI[sha256sum] = "cccc8e32c9cf206f2dfc9db3619686439c3e05b9d352be8ac951c99c9ad86273"
