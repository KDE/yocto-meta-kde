# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.80/src/krecorder-24.01.80.tar.xz"
SRC_URI[sha256sum] = "e17a58c6245dd70699ee5345dec827f38a88524f589e6ef8012262fc4acbc8b0"
