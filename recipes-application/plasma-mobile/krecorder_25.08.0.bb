# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.08.0/src/krecorder-25.08.0.tar.xz"
SRC_URI[sha256sum] = "7c2838a0cb6171f273f98f2d0b9b9908163e426f957b8af947506be8d8e2107a"
