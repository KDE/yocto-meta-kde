# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.12.1/src/kasts-24.12.1.tar.xz"
SRC_URI[sha256sum] = "1b04c81d5a8adbc6f89120e0fafaf123c8d7e677c850ba3921de4e66d3abf00c"
