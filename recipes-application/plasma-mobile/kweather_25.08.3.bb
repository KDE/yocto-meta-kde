# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.08.3/src/kweather-25.08.3.tar.xz"
SRC_URI[sha256sum] = "28da1e2ead6c726e6232230eaa8f1e0e5b9a6b90b756030ec7f9151d190d732d"
