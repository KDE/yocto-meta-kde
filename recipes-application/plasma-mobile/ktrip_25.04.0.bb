# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.04.0/src/ktrip-25.04.0.tar.xz"
SRC_URI[sha256sum] = "e655f40ba47ddc008979905247d0e23c0509d1e11d84b14e45c4183c01d8d0ae"
