# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.95/src/koko-24.01.95.tar.xz"
SRC_URI[sha256sum] = "5745e658d117ab3650d77f0e36b53e1ff1c60ef1c3aad96f3040713ff9b636e4"
