# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.08.0/src/kasts-24.08.0.tar.xz"
SRC_URI[sha256sum] = "56c5ef8171fc812d692060125c9ee968e4f43fb0f0d3915e768085fbe26b06c8"
