# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.85/src/kongress-24.01.85.tar.xz"
SRC_URI[sha256sum] = "9ec9e21f171f478b17783febc73e375ab5d95d3eea601683fa5060ba3d12166d"
