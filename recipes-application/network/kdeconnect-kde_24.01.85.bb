# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.85/src/kdeconnect-kde-24.01.85.tar.xz"
SRC_URI[sha256sum] = "c2a19cc36e6fdab7caf8697c997ef35e93853123faabfa58b034f2fe28f5bac1"
