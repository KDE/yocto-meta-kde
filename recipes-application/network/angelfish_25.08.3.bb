# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.08.3/src/angelfish-25.08.3.tar.xz"
SRC_URI[sha256sum] = "71c4a7b3d6650eb5bd9a7d082ce03eface0bb5e806d8f399e7ad675bb064376c"
