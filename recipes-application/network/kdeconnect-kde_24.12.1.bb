# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.12.1/src/kdeconnect-kde-24.12.1.tar.xz"
SRC_URI[sha256sum] = "df2a1ad146ff2fb34e735d141d4cde574eca43cd0f7a7eab259c8703e02ad62c"
