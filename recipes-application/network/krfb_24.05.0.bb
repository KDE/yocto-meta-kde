# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.05.0/src/krfb-24.05.0.tar.xz"
SRC_URI[sha256sum] = "aa8f7281d3a3e44ab7e2087b7e567e3fed125e45d35509c03a8afbd4ee0dda95"
