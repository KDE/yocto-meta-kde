# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/22.04.3/src/kdeconnect-kde-22.04.3.tar.xz"
SRC_URI[sha256sum] = "9df40473469e73fbb865e1d0fcbe530b10b49d0f652f9265dd4237cae8ebaf04"
