# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.12.1/src/krfb-24.12.1.tar.xz"
SRC_URI[sha256sum] = "62b9fc74a21431346cb44791cfc2cc82834bba41e10c916e6d2b2ffe2f256ed4"
