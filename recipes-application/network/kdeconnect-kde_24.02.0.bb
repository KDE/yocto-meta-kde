# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.02.0/src/kdeconnect-kde-24.02.0.tar.xz"
SRC_URI[sha256sum] = "d95c5b3693d14b954fb09a22d2fc1712815aa424740cbf5872c40a59ed424e0d"
