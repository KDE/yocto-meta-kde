# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/26.04.1/src/krfb-26.04.1.tar.xz"
SRC_URI[sha256sum] = "591926a203a41546bf49239fc464f730b7ad1a4a3a5ae49204616d2b635ed1fe"
