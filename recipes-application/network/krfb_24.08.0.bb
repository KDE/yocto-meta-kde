# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.08.0/src/krfb-24.08.0.tar.xz"
SRC_URI[sha256sum] = "d08c0aaa54ffa0558b04505da65563176995b75ac194a14b586da559910618c4"
