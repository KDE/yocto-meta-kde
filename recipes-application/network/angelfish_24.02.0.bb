# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.02.0/src/angelfish-24.02.0.tar.xz"
SRC_URI[sha256sum] = "820e6e2db1dd7528519976ffabc42a74df8dcd3ba189d743c1d2548d4197e9a0"
