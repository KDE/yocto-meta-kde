# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.08.3/src/angelfish-24.08.3.tar.xz"
SRC_URI[sha256sum] = "8e1db4ade94237d980fc82e53dd64d19db996301d5cdf1a7f6010b2ad8feadf4"
