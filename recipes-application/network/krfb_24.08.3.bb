# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.08.3/src/krfb-24.08.3.tar.xz"
SRC_URI[sha256sum] = "4b621387356bdb6c306405e30e2bd4859a170c781939ab0a120fb206e29a8c7e"
