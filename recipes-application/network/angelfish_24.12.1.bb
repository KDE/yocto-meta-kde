# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.12.1/src/angelfish-24.12.1.tar.xz"
SRC_URI[sha256sum] = "72e629bfa8eb9e73f0ec944b2f2a2af63933263da251ec31b98aec0265d23037"
