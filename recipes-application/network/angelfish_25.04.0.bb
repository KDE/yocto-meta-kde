# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.04.0/src/angelfish-25.04.0.tar.xz"
SRC_URI[sha256sum] = "1bcd45392044a0fa1ccbcf1a4bba859db0fd17da96227572d59d7b2b0297e421"
