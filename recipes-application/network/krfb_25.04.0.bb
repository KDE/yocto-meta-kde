# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.04.0/src/krfb-25.04.0.tar.xz"
SRC_URI[sha256sum] = "b4fd5369de7c7f135dd41a304cb865a5fd3272483649cf39c50821bf8cfe0751"
