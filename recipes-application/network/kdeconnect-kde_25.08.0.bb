# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.08.0/src/kdeconnect-kde-25.08.0.tar.xz"
SRC_URI[sha256sum] = "edc6d8d5bb3aab53208a229528ef36a5bc959bfaec17512b5621502d1d37d260"
