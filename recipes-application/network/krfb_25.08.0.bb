# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.08.0/src/krfb-25.08.0.tar.xz"
SRC_URI[sha256sum] = "f353c6603046fe97fd0808497d47a3eb18bbd7811e43d08c965414214496845a"
