# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.12.1/src/kdeconnect-kde-25.12.1.tar.xz"
SRC_URI[sha256sum] = "7d63857b7e1c27a00dbdbab26fa384fc7d93bfe32d82b95943a944d477be5ad7"
