# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

PV = "24.02.1"
require ${BPN}.inc
SRCREV = "fb0ff21e5216b59f92ea00dac0dec0edc446e3c2"
