# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.05.0/src/kdeconnect-kde-24.05.0.tar.xz"
SRC_URI[sha256sum] = "b05f5ee164160a7ffaa1269a27fd2a55006dd009f66c6bf10530bce2d9d980cd"
