# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.04.0/src/kdeconnect-kde-25.04.0.tar.xz"
SRC_URI[sha256sum] = "144a65ed741dd37bec4e30703c939f49b8becdb51075bd5702d7adede91d5ca8"
