# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.90/src/kdeconnect-kde-24.01.90.tar.xz"
SRC_URI[sha256sum] = "83db9d2039766b8605bd0322fbd4b4749063771715effb7875621cfc778018b0"
