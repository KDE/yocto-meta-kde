# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.95/src/kdeconnect-kde-24.01.95.tar.xz"
SRC_URI[sha256sum] = "1143e6bbb7ae8db35a5d7a62e3b98ce99dbd184124259e2813e42986da42c586"
