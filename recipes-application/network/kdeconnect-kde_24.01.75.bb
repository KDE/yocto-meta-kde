# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.75/src/kdeconnect-kde-24.01.75.tar.xz"
SRC_URI[sha256sum] = "1944f105dd4f9d814e74ef194e2935ba63d7a894432afcb19f20b3bbb71194ad"
