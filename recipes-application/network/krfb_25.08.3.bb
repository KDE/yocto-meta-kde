# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.08.3/src/krfb-25.08.3.tar.xz"
SRC_URI[sha256sum] = "e12f879089b6a9d4b8fc72b8201e52223ea450664d28ba3a43193a61eb9dff42"
