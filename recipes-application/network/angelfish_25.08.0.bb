# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.08.0/src/angelfish-25.08.0.tar.xz"
SRC_URI[sha256sum] = "0926325a19f2cc72e4a54fdacec5eb7cb15044e6129d28d1a959a706ad1c2d7c"
