# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.08.3/src/kdeconnect-kde-24.08.3.tar.xz"
SRC_URI[sha256sum] = "10e05e89bdaa02291d8b6d07ec1af90040a87ec2bc01bf96a68c8a11434fff68"
