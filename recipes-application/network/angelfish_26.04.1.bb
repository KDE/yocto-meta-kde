# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/26.04.1/src/angelfish-26.04.1.tar.xz"
SRC_URI[sha256sum] = "1dfd5bb6816b749bd0ad21aa3a53f870abe29646c56d6921b0f811098e8a5aa9"
