# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.80/src/kdeconnect-kde-24.01.80.tar.xz"
SRC_URI[sha256sum] = "11636cfe61ba55eaf4029bdf5f42a63f5e995469561c656a1103209721564539"
