# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.08.0/src/angelfish-24.08.0.tar.xz"
SRC_URI[sha256sum] = "8ce51d5b8dc01dc0754ce15331e88ab1b344942a19c5082a2c54a809c068ee74"
