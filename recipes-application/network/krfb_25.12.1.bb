# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.12.1/src/krfb-25.12.1.tar.xz"
SRC_URI[sha256sum] = "e6a43161fda9f0a5cf1a750fbb90866049aa198a9e0c3987added54009f28969"
