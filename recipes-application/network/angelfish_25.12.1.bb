# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.12.1/src/angelfish-25.12.1.tar.xz"
SRC_URI[sha256sum] = "93d0230d0c2738c7782cb509623b8e6b7106950b10a3af891cc1820640823f4e"
