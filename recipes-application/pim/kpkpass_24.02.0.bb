# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.02.0/src/kpkpass-24.02.0.tar.xz"
SRC_URI[sha256sum] = "a2e3afe04cdab2fd7b2536d9b0ecf34036d274d2aa364de037cd5609fb3b08df"
