# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.08.3/src/kitinerary-25.08.3.tar.xz"
SRC_URI[sha256sum] = "b37406fdb6a5135fbc17c88ccb7f2d0888e6d53e16f42d8194ea618911f47220"