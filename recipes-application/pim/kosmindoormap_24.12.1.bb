# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.12.1/src/kosmindoormap-24.12.1.tar.xz"
SRC_URI[sha256sum] = "89d7639f2dca532301159b5640e4cd4f5177923213ea1bb60692424945ac68c6"
