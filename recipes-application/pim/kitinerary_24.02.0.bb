# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.02.0/src/kitinerary-24.02.0.tar.xz"
SRC_URI[sha256sum] = "e18c62363607dd769092e9e15fce3e00250d706f78d1c7d8ad2835bc620d977a"
