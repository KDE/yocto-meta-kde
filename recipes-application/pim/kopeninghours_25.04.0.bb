# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.04.0/src/kopeninghours-25.04.0.tar.xz"
SRC_URI[sha256sum] = "b211bcdd2d38b297957b0694c74faf57fa89bc6a5aa610dd24582869afa4a31a"
