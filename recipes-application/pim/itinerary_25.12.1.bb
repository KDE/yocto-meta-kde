# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.12.1/src/itinerary-25.12.1.tar.xz"
SRC_URI[sha256sum] = "61464ad3d0680de6d7d2a7ed347156382464113b9362d7e9bd94ab99337fcc6c"
