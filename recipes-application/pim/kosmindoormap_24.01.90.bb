# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.90/src/kosmindoormap-24.01.90.tar.xz"
SRC_URI[sha256sum] = "dbb0a35cc82c79c61b5a35c425738ee0ebc3e25a66b5ce913202719a47838b56"
