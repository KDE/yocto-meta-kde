# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/26.04.1/src/kmime-26.04.1.tar.xz"
SRC_URI[sha256sum] = "79616a7bc28710f8f2fc4e7eee53342e83c58969eef09ba70e63ee2017472e6a"
