# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.12.1/src/khealthcertificate-25.12.1.tar.xz"
SRC_URI[sha256sum] = "a1a96f90ea1210a5ea0f09e580aa7043d94d7f2636a7c1bd40b2c8ef3fa76e06"
