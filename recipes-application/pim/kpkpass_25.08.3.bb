# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.08.3/src/kpkpass-25.08.3.tar.xz"
SRC_URI[sha256sum] = "3802a6f23edd901be975c03b3eb63e478e9384386d883b2289fb598edf3e758b"
