# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.08.0/src/kmime-24.08.0.tar.xz"
SRC_URI[sha256sum] = "9e5aa90d8a2314b5fbc015f066922f2e1fa529daad3b76dfd351567a954353c2"
