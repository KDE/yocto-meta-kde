# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.08.0/src/kosmindoormap-24.08.0.tar.xz"
SRC_URI[sha256sum] = "b74c78e8e2038f75165dc9899a16498e524580c9ae687269a38d6c5a582ab299"
