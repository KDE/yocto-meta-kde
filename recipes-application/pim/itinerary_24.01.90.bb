# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.90/src/itinerary-24.01.90.tar.xz"
SRC_URI[sha256sum] = "de003b47014ec8269845668990ca4d5cad7bc45f7649553e7eb15bef42c4b1f4"
