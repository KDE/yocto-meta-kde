# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.90/src/kmime-24.01.90.tar.xz"
SRC_URI[sha256sum] = "012a853b60eea06594373b4f5a02954e44e4d99cf26469fafe874e55d728ecbf"
