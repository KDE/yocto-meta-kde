# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.08.3/src/kosmindoormap-25.08.3.tar.xz"
SRC_URI[sha256sum] = "1a2ce2c3e514bfe01e7b1fde943bf099121cad82a88f444bdac03b57509be3df"
