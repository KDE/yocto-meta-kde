# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.08.0/src/kpkpass-25.08.0.tar.xz"
SRC_URI[sha256sum] = "2ee2a25ff90f23026dd687e2b62ac1a908c1c55fdf685a42583d67472a1badbb"
