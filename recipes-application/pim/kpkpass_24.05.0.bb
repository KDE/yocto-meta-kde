# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.05.0/src/kpkpass-24.05.0.tar.xz"
SRC_URI[sha256sum] = "b370dc112507dbf87033d5a04914beeae9e653820374fd1b48b476f467d8ad28"
