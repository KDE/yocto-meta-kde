# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.08.3/src/kosmindoormap-24.08.3.tar.xz"
SRC_URI[sha256sum] = "37e859ccc525f0f5828f7d8c9de02a343928533ac20b48795e8b1791914a72f9"
