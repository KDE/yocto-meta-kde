# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.95/src/kmime-24.01.95.tar.xz"
SRC_URI[sha256sum] = "202f1b65b63ed2af59d17e9e4cf3808ce61e1da8c2f8c3aea65dadf4b4383d12"
