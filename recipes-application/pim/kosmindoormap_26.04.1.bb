# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/26.04.1/src/kosmindoormap-26.04.1.tar.xz"
SRC_URI[sha256sum] = "77114e34956a5a4284146a25e0bfba3bf42c10d09de4ef073ea0468f263f9765"
