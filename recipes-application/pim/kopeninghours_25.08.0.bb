# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.08.0/src/kopeninghours-25.08.0.tar.xz"
SRC_URI[sha256sum] = "94bae44259d7566b2a7c26411f3200fc40298bb1fc65d48060aa6a210afc4d50"
