# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.90/src/kitinerary-24.01.90.tar.xz"
SRC_URI[sha256sum] = "655bc68daead258eec3122cb0f0edcf01350cc769d7d3c57aeb6ab0220953567"
