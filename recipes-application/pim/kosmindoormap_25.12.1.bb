# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.12.1/src/kosmindoormap-25.12.1.tar.xz"
SRC_URI[sha256sum] = "98ff93d40bc5190a5bdcccc2ab835af57eeba6283ef673d795fc68d829be77fb"
