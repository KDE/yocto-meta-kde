# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.95/src/kitinerary-24.01.95.tar.xz"
SRC_URI[sha256sum] = "73c787fd28a7ca3f7d47f1568a43602d6457d213239d8d6680c17fa1b03edb76"
