# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.12.1/src/itinerary-24.12.1.tar.xz"
SRC_URI[sha256sum] = "d10611e2b50cd96e8310de152006fe9339b1bc6c5f980b6d9a664812eb645634"
