# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.08.3/src/kpkpass-24.08.3.tar.xz"
SRC_URI[sha256sum] = "bace2a9d11d712d5a5b9f1e61c13b33ae450a29db730de807597e4ccec43ea48"
