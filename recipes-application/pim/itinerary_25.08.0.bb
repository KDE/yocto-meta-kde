# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.08.0/src/itinerary-25.08.0.tar.xz"
SRC_URI[sha256sum] = "1f2c10c1f47a5919f447accdf60997038a528a66b8ee172fcc184dd2bd2f2716"
