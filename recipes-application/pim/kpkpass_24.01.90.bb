# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.90/src/kpkpass-24.01.90.tar.xz"
SRC_URI[sha256sum] = "d7f4f05ba9fa56d9bd7d267fa8bdbc832dd505911a13588b64f240bd1406138b"
