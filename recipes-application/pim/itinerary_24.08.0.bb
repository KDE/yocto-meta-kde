# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.08.0/src/itinerary-24.08.0.tar.xz"
SRC_URI[sha256sum] = "166864fb078f4e83739b3672a824efba50b87e08e366f7c4edf94555f54d0435"
