# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.02.0/src/kopeninghours-24.02.0.tar.xz"
SRC_URI[sha256sum] = "095a3cc15901fc41816add0cacb98da46435667ac24be18ec55f6fba05818477"
