# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.08.3/src/itinerary-24.08.3.tar.xz"
SRC_URI[sha256sum] = "226f31c887eed3dc105f50295669c13ac018d1b27587a07228471c0d4913c75f"
