# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.08.3/src/itinerary-25.08.3.tar.xz"
SRC_URI[sha256sum] = "28f8cef47f949ce48326f6d2882d58c1c797a6e324c51f5d3510e7db22161f87"
