# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.08.0/src/kitinerary-24.08.0.tar.xz"
SRC_URI[sha256sum] = "befb95f1620e0c9baa82264aabfba0cc676c9ee40583938be2091f1254f2cdac"
