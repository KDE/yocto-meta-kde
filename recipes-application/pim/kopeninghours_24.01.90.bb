# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.90/src/kopeninghours-24.01.90.tar.xz"
SRC_URI[sha256sum] = "869a2071b12f2ae0f0e73d169d753aece767d42c439f87ae8f4db66d2fc3eabc"
