# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.95/src/itinerary-24.01.95.tar.xz"
SRC_URI[sha256sum] = "8a9094b8ef633b23fda4da1e446fe8dc0580a75509e5e86553a72ca427287984"
