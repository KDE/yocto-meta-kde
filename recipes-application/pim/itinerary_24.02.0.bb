# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.02.0/src/itinerary-24.02.0.tar.xz"
SRC_URI[sha256sum] = "6d63abc13fce4cd0804dbfc1c9b7c6595b833972758bd8d8207e1210a5e7c943"
