# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.04.0/src/itinerary-25.04.0.tar.xz"
SRC_URI[sha256sum] = "37755caaf2e55a841f72922c9ce4932e1ad346bafc1e9cca136d111f6d6793e8"
