# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.95/src/kopeninghours-24.01.95.tar.xz"
SRC_URI[sha256sum] = "89234731f95594884515bd90fdfef8e0a2774add35e23bedee906d22c7d34b21"
