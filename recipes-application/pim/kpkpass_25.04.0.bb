# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.04.0/src/kpkpass-25.04.0.tar.xz"
SRC_URI[sha256sum] = "39bde1831f700555c89ac06214510b9f1e58f2f5e5836ec11196b07ff1f6216a"
