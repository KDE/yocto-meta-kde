# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.12.1/src/kopeninghours-25.12.1.tar.xz"
SRC_URI[sha256sum] = "641ffd1bfd5702e47f39286747f72f30d116bde25356bddbd1ac1fb186d58aaf"
