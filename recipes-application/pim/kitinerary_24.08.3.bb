# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.08.3/src/kitinerary-24.08.3.tar.xz"
SRC_URI[sha256sum] = "f0ff4d103c93e24770d94432afd0acf456efca70e00d4749d734a5ff98cfd14b"
