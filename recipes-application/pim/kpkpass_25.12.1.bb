# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.12.1/src/kpkpass-25.12.1.tar.xz"
SRC_URI[sha256sum] = "44e8716849392ab3bbb2bac812d6abebb383843982c070f2520e34d9e8354d97"
