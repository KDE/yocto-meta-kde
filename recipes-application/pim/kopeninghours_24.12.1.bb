# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.12.1/src/kopeninghours-24.12.1.tar.xz"
SRC_URI[sha256sum] = "668681ed05df9d038533e291cd759d1b4583b82baa65291628d4b77fc885127d"
