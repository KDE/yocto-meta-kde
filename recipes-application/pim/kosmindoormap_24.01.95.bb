# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.95/src/kosmindoormap-24.01.95.tar.xz"
SRC_URI[sha256sum] = "9175588baecc036d8e1d87204da05d7fe3dc5b9bfe117fcf26727605fe39a8d3"
