# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/26.04.1/src/kitinerary-26.04.1.tar.xz"
SRC_URI[sha256sum] = "5d1adc66de813d369730ee20bc8bec83af84e41075aea71f22fa200247b752ad"
