# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.05.0/src/kopeninghours-24.05.0.tar.xz"
SRC_URI[sha256sum] = "cacc6097d8e6dcdfc33e80ee4148a68c97de2ec0116c7f47ef897801f17151fb"
