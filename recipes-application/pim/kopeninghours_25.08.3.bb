# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.08.3/src/kopeninghours-25.08.3.tar.xz"
SRC_URI[sha256sum] = "0e60885d2cdb88fe0bf42fe39f01c9e284dd755727c585714832eba98c11cb73"