# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.08.0/src/kosmindoormap-25.08.0.tar.xz"
SRC_URI[sha256sum] = "46151160bfce5f855e4df6febbdf9e4887f4addd745749dd0888aa9a12d121cb"
