# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.05.0/src/itinerary-24.05.0.tar.xz"
SRC_URI[sha256sum] = "b631c8179e3ea53f48d68a48583470a2f94a475d3c893725e8d241f7d76f971b"
