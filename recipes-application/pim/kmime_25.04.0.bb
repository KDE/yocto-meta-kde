# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.04.0/src/kmime-25.04.0.tar.xz"
SRC_URI[sha256sum] = "7a8e4176ef28c117d55936b703bb541ec6c0410c52de8e40182aea8965e21ba4"
