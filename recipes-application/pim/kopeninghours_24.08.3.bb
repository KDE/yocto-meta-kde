# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.08.3/src/kopeninghours-24.08.3.tar.xz"
SRC_URI[sha256sum] = "847880d4ae9887e0ab502ca9ca934a60259e3b4685de50d4a72b0089ed9caeb4"
