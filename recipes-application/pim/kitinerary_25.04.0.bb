# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.04.0/src/kitinerary-25.04.0.tar.xz"
SRC_URI[sha256sum] = "8da99e35247cd424dbeaee03519615490ab9f1f0ae58fd24f7b45e358b230bbe"
