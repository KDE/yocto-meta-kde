# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.08.0/src/kopeninghours-24.08.0.tar.xz"
SRC_URI[sha256sum] = "d9c97b3c6ffc6c7105bc1f890788475a86e47bc02787916dae6459bdcc3658d6"
