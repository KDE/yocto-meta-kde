# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.04.0/src/kosmindoormap-25.04.0.tar.xz"
SRC_URI[sha256sum] = "b85994daf6f71629281774825e09aee1b014813a9741ed98b70baff3cf56ab50"
