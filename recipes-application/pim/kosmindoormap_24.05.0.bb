# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.05.0/src/kosmindoormap-24.05.0.tar.xz"
SRC_URI[sha256sum] = "f3995fd899b70f70bcff22d91596d414303473ceafe24aa4e8d05b0436efc536"
