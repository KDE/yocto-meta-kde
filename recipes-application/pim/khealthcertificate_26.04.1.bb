# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/26.04.1/src/khealthcertificate-26.04.1.tar.xz"
SRC_URI[sha256sum] = "8d2b3bef90e78d35a99019466cfc8856d1775881925a2836b2fb9efb297b33c1"
