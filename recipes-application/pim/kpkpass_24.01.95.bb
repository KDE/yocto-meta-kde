# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.95/src/kpkpass-24.01.95.tar.xz"
SRC_URI[sha256sum] = "e366f5b8becf40c1325e8fd196130466dc24dc6d4651e78cb9df7a6961423203"
