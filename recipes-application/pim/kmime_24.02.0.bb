# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.02.0/src/kmime-24.02.0.tar.xz"
SRC_URI[sha256sum] = "4f1251484f18b6eedf62c9219a504e6357de5adff4016cc34a714dd0cb748065"
