# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.85/src/kpublictransport-24.01.85.tar.xz"
SRC_URI[sha256sum] = "93104897d2e857dde1312c8f7c72cde00ee775a0e5edaa8a757c1ce9460853aa"
