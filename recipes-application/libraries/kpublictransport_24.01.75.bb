# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.75/src/kpublictransport-24.01.75.tar.xz"
SRC_URI[sha256sum] = "8b0d4a821cd0b6ca4112614c059f2d9d108efc0072ab6bdb2876ffd84b9c6e75"
