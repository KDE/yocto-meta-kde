# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.12.1/src/kdegraphics-thumbnailers-25.12.1.tar.xz"
SRC_URI[sha256sum] = "3b1806198588ecb8cd27ffe56999d5384a19ef3ec6be0dfcf04d67947daad7f9"
