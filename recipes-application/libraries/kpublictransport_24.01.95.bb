# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.95/src/kpublictransport-24.01.95.tar.xz"
SRC_URI[sha256sum] = "6b84498853561154c48033a93f2b2b9d4c975981a84ad28fdddb66cb5ccd4e8c"
