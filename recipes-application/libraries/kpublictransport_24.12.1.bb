# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.12.1/src/kpublictransport-24.12.1.tar.xz"
SRC_URI[sha256sum] = "6aa1a526e01abaad0ed8af5484219496eae0bbe8b87e76e65dea05d47d4221c2"
