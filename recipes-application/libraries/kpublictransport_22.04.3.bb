# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/22.04.3/src/kpublictransport-22.04.3.tar.xz"
SRC_URI[sha256sum] = "3f87338567fd931ae3f2ec43141cb2671d8b9ef30d8f1a550b7f9363f1ad4817"
