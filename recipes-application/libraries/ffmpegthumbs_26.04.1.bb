# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/26.04.1/src/ffmpegthumbs-26.04.1.tar.xz"
SRC_URI[sha256sum] = "df38f6782f02f4a941c25bee7edee22f48865109e27419c599b71d155a57f4fe"
