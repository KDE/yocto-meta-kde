# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.90/src/kpublictransport-24.01.90.tar.xz"
SRC_URI[sha256sum] = "2f2e67ad1510275acd42564c36ee480b9dc4e05d3e01fbb1137417e8d1f396e5"
