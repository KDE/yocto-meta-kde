# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.08.0/src/kpublictransport-25.08.0.tar.xz"
SRC_URI[sha256sum] = "fd0190081f4be172711ec1e0e5702805bcf9c00c73a08a42ba3790167cabab0a"
