# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.08.3/src/kpublictransport-25.08.3.tar.xz"
SRC_URI[sha256sum] = "ed887df23d04a1ebd171b59c99dfaec26d62254e9a7ac4f8a7084ba301586c17"
