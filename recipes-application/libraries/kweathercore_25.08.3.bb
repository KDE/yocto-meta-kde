# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.08.3/src/kweathercore-25.08.3.tar.xz"
SRC_URI[sha256sum] = "693573a0245bf65daceab127ac45c9acfbb39e6b7c516d817af541cd3125b25b"
