# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.05.0/src/kpublictransport-24.05.0.tar.xz"
SRC_URI[sha256sum] = "a9a25ad3398a2dc928bb69add1947c839d73ce8e00957b7bbd6b985477f437bb"
