# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.04.0/src/kweathercore-25.04.0.tar.xz"
SRC_URI[sha256sum] = "17f208e4a126778f1fbd179522792c6aca1dd614a06ce4cd5452a5fe6f67cd4c"
