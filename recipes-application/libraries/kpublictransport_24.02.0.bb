# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.02.0/src/kpublictransport-24.02.0.tar.xz"
SRC_URI[sha256sum] = "8addc5cde31ed54d9d18c7247aaefd669bde10a8cd76403784dd0bcff9cd22f8"
