# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/26.04.1/src/kpublictransport-26.04.1.tar.xz"
SRC_URI[sha256sum] = "e491c9e6aa85e662412c62ea36895f73bed33600633761dbe8fac14500e777ff"
