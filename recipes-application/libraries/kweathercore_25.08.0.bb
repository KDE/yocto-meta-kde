# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.08.0/src/kweathercore-25.08.0.tar.xz"
SRC_URI[sha256sum] = "1b97e95aec8f1930244ae5c400712056109b3ed22fa5b6994834cd714bbe324a"
