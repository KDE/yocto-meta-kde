# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.12.1/src/kweathercore-25.12.1.tar.xz"
SRC_URI[sha256sum] = "071c567a33f4d7c1849ab03cf762d295ea1f8b22755036a915715ad013508907"
