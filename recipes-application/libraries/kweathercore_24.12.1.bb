# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.12.1/src/kweathercore-24.12.1.tar.xz"
SRC_URI[sha256sum] = "9d1115764ce5ca1370fd08af33964551cfd2cde784f46527fc83562680d96f7f"
