# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/26.04.1/src/kdegraphics-thumbnailers-26.04.1.tar.xz"
SRC_URI[sha256sum] = "684fe7c8bd600b99909908f816189940a3e4b8fcf3151e52db798342f529c200"
