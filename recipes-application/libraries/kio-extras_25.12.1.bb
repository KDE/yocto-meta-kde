# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.12.1/src/kio-extras-25.12.1.tar.xz"
SRC_URI[sha256sum] = "df464e3cf9ee83d72f5346e37941bed05eea1d0e5f49dfd81c940aeaec369d57"
