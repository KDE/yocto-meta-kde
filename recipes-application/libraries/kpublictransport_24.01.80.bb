# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.80/src/kpublictransport-24.01.80.tar.xz"
SRC_URI[sha256sum] = "0c67408a0c054d0a8d444c56fa6221d4cd6b4302e1d817a27eae730ed3c0fac3"
