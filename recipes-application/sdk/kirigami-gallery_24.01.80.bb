# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.80/src/kirigami-gallery-24.01.80.tar.xz"
SRC_URI[sha256sum] = "ac9d77238a840f4f25390b317d2e62851f96136c508db4415e832914144128ed"
