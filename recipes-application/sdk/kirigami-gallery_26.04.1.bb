# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/26.04.1/src/kirigami-gallery-26.04.1.tar.xz"
SRC_URI[sha256sum] = "5c33118b8bf1854e4b622352a23ddbaef20d092ad553b8005b5d7b0ab0200dcb"
