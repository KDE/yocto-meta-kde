# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.02.0/src/kirigami-gallery-24.02.0.tar.xz"
SRC_URI[sha256sum] = "1bea4b9ee328254ef6aecaddae1d1d8e11c00034e1587bc82b2a76ca2e624c8c"
