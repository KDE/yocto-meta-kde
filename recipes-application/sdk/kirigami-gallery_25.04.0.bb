# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.04.0/src/kirigami-gallery-25.04.0.tar.xz"
SRC_URI[sha256sum] = "d3abc3db132c6e41aa83ee28edf92e066e24a0b0123180410a4428f2fd21a555"
