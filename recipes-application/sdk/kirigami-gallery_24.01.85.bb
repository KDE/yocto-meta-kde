# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.85/src/kirigami-gallery-24.01.85.tar.xz"
SRC_URI[sha256sum] = "a1163da7993e88cabe7f64ab212367f38742a047f55f0c66760e4458d84b6b88"
