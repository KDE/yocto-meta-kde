# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.08.3/src/kirigami-gallery-24.08.3.tar.xz"
SRC_URI[sha256sum] = "5120fbbe901992105db8d5d0dabb76297f786122a8700dc16041f7e20cc17dd8"
