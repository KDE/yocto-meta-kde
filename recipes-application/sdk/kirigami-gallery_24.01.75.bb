# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.75/src/kirigami-gallery-24.01.75.tar.xz"
SRC_URI[sha256sum] = "18120f4a38a3b8a7473189ea179562cbadb872936b5ae6b64ad884a0c901f3e8"
