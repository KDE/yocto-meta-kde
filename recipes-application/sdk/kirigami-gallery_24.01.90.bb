# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.90/src/kirigami-gallery-24.01.90.tar.xz"
SRC_URI[sha256sum] = "e80ede8c7251779115a3c9f7f223e4a512bdacda152c743dbf87edc434f4a7fa"
