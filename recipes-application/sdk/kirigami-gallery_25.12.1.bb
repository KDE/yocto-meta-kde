# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.12.1/src/kirigami-gallery-25.12.1.tar.xz"
SRC_URI[sha256sum] = "df651f0d56599becc1b8a9051814c509068a5e896f11aa170af5aed3bf8ad69a"
