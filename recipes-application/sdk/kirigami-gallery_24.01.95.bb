# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/unstable/release-service/24.01.95/src/kirigami-gallery-24.01.95.tar.xz"
SRC_URI[sha256sum] = "fceade13b4c8c30917d81fddf646ab6dcf67a416ac7962fe844b45ef666fabb0"
