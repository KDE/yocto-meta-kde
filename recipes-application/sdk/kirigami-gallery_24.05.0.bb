# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.05.0/src/kirigami-gallery-24.05.0.tar.xz"
SRC_URI[sha256sum] = "9d7f984cd97fa81bc4dd02ca43ec08e6c7d3fffbbfce4871fc68c0c8a4e7472f"
