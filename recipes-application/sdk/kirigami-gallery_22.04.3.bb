# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/22.04.3/src/kirigami-gallery-22.04.3.tar.xz"
SRC_URI[sha256sum] = "b06ef98a0dc34e7fa1fbe94b26c132f62e3d03b8a751d0f1705e94e6213c3f8c"
