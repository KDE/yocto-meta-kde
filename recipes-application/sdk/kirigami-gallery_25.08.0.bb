# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.08.0/src/kirigami-gallery-25.08.0.tar.xz"
SRC_URI[sha256sum] = "ba89fb934ded45afbd2ed7b4a5b7aff2d2c80eca931168417d6e04951a83c1aa"
