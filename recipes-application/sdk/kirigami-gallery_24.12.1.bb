# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.12.1/src/kirigami-gallery-24.12.1.tar.xz"
SRC_URI[sha256sum] = "76a0ea878ea11529c12ad7254bd61274fc344d854fd6cf737403f649f209124c"
