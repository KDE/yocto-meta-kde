# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/24.08.0/src/kirigami-gallery-24.08.0.tar.xz"
SRC_URI[sha256sum] = "5298ab4156833f7fb65fa421fa0f9f63b578bdcf87c3d380224e9fb3b132c44a"
