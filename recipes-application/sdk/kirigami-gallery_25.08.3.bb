# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/release-service/25.08.3/src/kirigami-gallery-25.08.3.tar.xz"
SRC_URI[sha256sum] = "dfe7e59885ec481a67e887a2bef1a09128fc3a862e00b44a4c962fd872661686"
