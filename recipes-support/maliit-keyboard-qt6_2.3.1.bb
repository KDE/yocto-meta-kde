# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${BPN}.inc
SRCREV = "9673c8e8bd64e091df6a07346919e476285fb04f"
