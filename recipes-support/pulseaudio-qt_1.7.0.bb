# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${BPN}.inc
SRC_URI = "git://invent.kde.org/libraries/${BPN};nobranch=1;protocol=https"
SRCREV = "cdde86de70e1ea540ead2577e4320d452dad94b9"
S = "${UNPACKDIR}/git"
