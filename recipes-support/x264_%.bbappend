# SPDX-FileCopyrightText: 2026 Frank Zhang <rmxpzlb@gmail.com>
#
# SPDX-License-Identifier: MIT

PACKAGECONFIG:remove = "ffmpeg"
