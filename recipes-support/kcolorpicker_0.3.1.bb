# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRCREV = "522e38b61e0786b97b2114c273a4551c869335be"
