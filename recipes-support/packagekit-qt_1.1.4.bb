# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${BPN}.inc
SRC_URI = "git://github.com/PackageKit/PackageKit-Qt.git;protocol=https;branch=main"
SRCREV = "72708dbbe4ae8ca56b9eb4d8dee72cc1ec0534b5"
S="${WORKDIR}/git"
