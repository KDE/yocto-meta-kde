# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${BPN}.inc
SRCREV = "9c127c3b418785f9203b2e3b72e7a9735ee9d744"
