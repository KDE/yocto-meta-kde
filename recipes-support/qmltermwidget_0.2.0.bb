# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
# this hash is slightly ahead of the 0.2.0 release
SRCREV = "63228027e1f97c24abb907550b22ee91836929c5"
