# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRCREV = "84f6152fba5a62fc9acc24bbdec970624a331f7c"
