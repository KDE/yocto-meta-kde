# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${BPN}.inc
SRCREV = "320d08b27ded451e8c5b850385c8642b4424d544"
