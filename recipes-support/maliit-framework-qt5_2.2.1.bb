# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${BPN}.inc
SRCREV = "ad906cad4acd8a81f62ea34f70e81a2bd4f7e926"
