# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${BPN}.inc
# SRCREV = "v${PV}"
SRCREV = "ffa841ec9766e4428f2f960b966bcc5b4e7e4982"
