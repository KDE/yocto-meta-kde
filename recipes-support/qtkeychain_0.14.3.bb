# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRCREV = "bc4b560fe7e3a8be58b96bd7d2a0b680628db2a2"
