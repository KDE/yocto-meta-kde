# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${BPN}.inc
SRCREV = "3cc27bd3759a6791c6fbdb0ad3a2f6e2dd07260e"
