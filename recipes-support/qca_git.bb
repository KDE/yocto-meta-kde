require ${BPN}.inc
SRCREV = "63fd27fbce780bccb9c9b3ff6649888cfd809c6a"
