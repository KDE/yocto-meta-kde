# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRCREV = "a4a46ef2eae8d7e9abf3eddee949ffca49548678"
