# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${BPN}.inc
SRCREV = "547dcbd4962b6da319bbf98506e9dc86ef248a05"
