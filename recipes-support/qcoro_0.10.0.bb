# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRCREV = "fa5bc4296a252ad71c85209b60675bb025024a1e"
