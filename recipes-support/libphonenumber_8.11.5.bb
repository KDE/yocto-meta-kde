# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRCREV = "df9d37a1a002cf22b479a113d069326dfb1b781f"
