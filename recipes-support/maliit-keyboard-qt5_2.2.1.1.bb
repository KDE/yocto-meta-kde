# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${BPN}.inc
SRCREV = "ae81a17b07f22d3b0d57997f0dfea1e8e91aa25f"
