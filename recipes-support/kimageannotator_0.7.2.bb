# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRCREV = "c481a8936946da6c81cd9042eca3d7aeed8d6982"
