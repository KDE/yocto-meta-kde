# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
PV = "1.6.1"
SRCREV = "a751c6cf3939c6184b4c8580230d5d8d88877ea8"
