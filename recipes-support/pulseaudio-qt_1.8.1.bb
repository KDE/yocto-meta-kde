# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${BPN}.inc
SRC_URI = "git://invent.kde.org/libraries/${BPN};nobranch=1;protocol=https"
SRCREV = "10786fe31e640858f4f5db5366aed9c56d77bfab"
