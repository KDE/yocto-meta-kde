# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRCREV = "ef1231ae490465b4f592ca326eee6d56a3d802ae"
