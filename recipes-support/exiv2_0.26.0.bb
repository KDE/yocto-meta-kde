# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${BPN}.inc
# SRCREV = "v${PV}"
# release version has no matching tag name!?
SRCREV = "0.26"
