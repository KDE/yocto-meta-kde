# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${BPN}.inc
SRCREV = "031a368a87e8aa8db62794a9be6139c27baafc26"
