require ${PN}.inc
# SRCREV = "v${PV}"
# 0.17.0 tries to run generated binaries durign the build, which fails when cross-compiling
SRCREV = "develop"
