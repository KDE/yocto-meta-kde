# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
# use unreleased tag for building with Qt6
SRCREV = "5055884ee6ae652474d6eebb940767a811b5d968"
PV = "0.19.0+git${SRCPV}"
