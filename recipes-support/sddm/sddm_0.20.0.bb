# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRCREV = "a9a664df36c2109d999aa841df7c8856ff68f350"
