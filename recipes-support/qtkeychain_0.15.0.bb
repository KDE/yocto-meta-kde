# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "git://github.com/frankosterfeld/qtkeychain.git;nobranch=1;protocol=https"
SRCREV = "ad7344c45a86a4f66cbafc4b081b5f7b876cb0b7"
S = "${UNPACKDIR}/git"
