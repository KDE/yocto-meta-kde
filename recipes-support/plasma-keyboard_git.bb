# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${BPN}.inc
SRC_URI = "git://invent.kde.org/plasma/plasma-keyboard.git;branch=master;protocol=https"
SRCREV = "46f3c89b2cecccc60861aa2da5f8eb155889e6ef"
S = "${WORKDIR}/git"
