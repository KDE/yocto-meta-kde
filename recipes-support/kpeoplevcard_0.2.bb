# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
#NOTE this is an arbitrary hash supporting Qt6
PV = "0.2"
SRCREV = "13db8a52125ec8abd830b3ffcd02691880e15c38"
