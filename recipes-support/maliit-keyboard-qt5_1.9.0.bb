# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${BPN}.inc
SRCREV = "432db0ea297652a0e19a19d36c30e5501f870d3d"
