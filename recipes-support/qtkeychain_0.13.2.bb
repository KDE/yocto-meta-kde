# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRCREV = "c236f9241e37f1754879cf8726d59351a2b2b24a"
