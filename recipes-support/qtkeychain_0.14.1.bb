# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRCREV = "69f993c47efed7e557d79a30a367014d9a27d809"
