# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
# release doesn't work :-(
# SRCREV = "telepathy-qt-${PV}"
SRCREV = "46bfa4ed74e0952c847ff0ea0087635af408d564"
