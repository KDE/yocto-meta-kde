# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
#NOTE this is an arbitrary hash supporting Qt6
PV = "0.1.1"
SRCREV = "5bf333027ab0e434dabdd7e6c734758eaae80c1c"
