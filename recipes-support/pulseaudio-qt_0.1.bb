# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
#NOTE this is an arbitrary hash supporting Qt6
PV = "1.3.90"
SRCREV = "39dcf82c208a642c4483efc58e67312997327c51"
