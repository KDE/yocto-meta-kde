require ${BPN}.inc
SRCREV = "v${PV}"
