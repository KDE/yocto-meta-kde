# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRCREV = "7f6c068beddd2a07165cce1ab3aa3158789fa3ba"
