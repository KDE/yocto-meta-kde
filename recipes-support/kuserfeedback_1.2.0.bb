# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRCREV = "3ed8cfdd131a7f217c5d24608a88bd977b46b96d"
