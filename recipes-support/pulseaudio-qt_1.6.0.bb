# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
PV = "1.6.0"
SRCREV = "18dbf1ccd6a7182cf0577e526d6bb7ff98886dd2"
