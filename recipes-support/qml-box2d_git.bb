# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${BPN}.inc
SRC_URI = "git://github.com/qml-box2d/qml-box2d.git;nobranch=1;protocol=https"
SRCREV = "3a85439726d1ac4d082308feba45f23859ba71e0"
S = "${UNPACKDIR}/git"
