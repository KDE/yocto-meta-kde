# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${BPN}.inc
SRC_URI = "git://github.com/PackageKit/PackageKit-Qt.git;protocol=https;branch=main"
SRCREV = "c888e1c7be5f8a7868c7728ab18d878376fb61b8"
S="${WORKDIR}/git"
