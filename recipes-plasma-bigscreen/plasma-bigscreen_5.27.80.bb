# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "git://invent.kde.org/plasma/${BPN};nobranch=1;protocol=https"
SRCREV = "4e961df46cc1816fd67a917178701eb4769353d6"
S = "${UNPACKDIR}/git"
