# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${BPN}.inc
SRCREV = "a751c6cf3939c6184b4c8580230d5d8d88877ea8"
