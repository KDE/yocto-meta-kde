# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${BPN}.inc
SRCREV = "773a361e388869b5f1252113b8c92e31b4e7be9e"
