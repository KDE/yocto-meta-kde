# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${BPN}.inc
SRCREV = "204f0ca4593563f2b7d5386c444f930e9491e71c"
