# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRCREV = "50ae6067a9dffbcee3e2597ec6815b9a1bcbf8d3"
