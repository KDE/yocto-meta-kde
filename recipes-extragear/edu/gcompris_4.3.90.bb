# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
# FIXME this is an aribtrary Qt6 compatible commit after release 4.3
SRCREV = "56c5ef9e829c0021d9e9c7dd3178c78552d39ac6"
