# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRCREV = "0ac513480426c8ce7fce983505111e7a61b02b9e"
