# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
# V25.1.1
SRCREV = "c3a9f1f0f7f7657250748277606955ba1a12929d"
