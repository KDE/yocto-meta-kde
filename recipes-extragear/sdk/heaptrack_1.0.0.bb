require ${PN}.inc
# TODO v1.0.0 (current latest release) doesn't build
# SRCREV = "v${PV}"
SRCREV = "master"
