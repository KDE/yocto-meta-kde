# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRCREV = "b54e92e88b0895f910a5b107f499d1155a086b80"
