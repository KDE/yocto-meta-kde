# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRCREV = "994301d7388960148b2dd2227b62b5a78945d7a7"
