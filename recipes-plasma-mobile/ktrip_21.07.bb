# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma-mobile/21.07/ktrip-21.07.tar.xz"
SRC_URI[sha256sum] = "291fc525f028cd61ea861c4d1492788382e74134dbccf91c599746713490f4a9"

