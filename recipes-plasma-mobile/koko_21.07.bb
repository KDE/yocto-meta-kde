# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma-mobile/21.07/koko-21.07.tar.xz"
SRC_URI[sha256sum] = "169a137af38764fbb85c59ab549980aa46dc7c5c7a7913ec9afd97556380e469"

