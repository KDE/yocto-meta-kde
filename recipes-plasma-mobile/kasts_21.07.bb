# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma-mobile/21.07/kasts-21.07.tar.xz"
SRC_URI[sha256sum] = "9910ff2f07b64c31155579820c7978c34071fd273e8c922f505c8d9f32dc6dc7"

