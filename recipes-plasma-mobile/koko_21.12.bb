# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma-mobile/21.12/koko-21.12.tar.xz"
SRC_URI[sha256sum] = "b4c261d8ef5263d7978f210ca7763f9a0a326702832a96efb3e6e52f9f85fda1"

