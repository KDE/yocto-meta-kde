# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma-mobile/23.01.0/plasma-settings-23.01.0.tar.xz"
SRC_URI[sha256sum] = "e786dd522969fea5be9f4e91ecfb8ccffc28127ba0de74f634aa9600bdfce03b"

