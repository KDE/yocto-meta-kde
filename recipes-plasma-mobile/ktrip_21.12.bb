# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma-mobile/21.12/ktrip-21.12.tar.xz"
SRC_URI[sha256sum] = "f9992c7ba8d6878e6738351a4dff6ee6ed56c0f66fd07cb7419030e3609061c4"

