# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma-mobile/22.09/krecorder-22.09.tar.xz"
SRC_URI[sha256sum] = "314a77eab8a14e79b93df5ee85493cbac662251e98c926a2826b70afd7e18f4d"

