# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma-mobile/22.11/alligator-22.11.tar.xz"
SRC_URI[sha256sum] = "54330ffaa8680519c43d6b9cbb48ae839198fd606f71e36b3878fa5dab200f0a"

