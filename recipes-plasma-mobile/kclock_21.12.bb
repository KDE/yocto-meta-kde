# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma-mobile/21.12/kclock-21.12.tar.xz"
SRC_URI[sha256sum] = "127790345d93087b9a457bfd164bbba5a819c0fa78b267cc09bcef9f46480694"

