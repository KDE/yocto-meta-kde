# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma-mobile/21.07/calindori-21.07.tar.xz"
SRC_URI[sha256sum] = "82bf32c18fd92f41c4871e3612cb7055b3ef0a6d035a536db88a34f7e98c8401"

