# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma-mobile/22.09/kclock-22.09.tar.xz"
SRC_URI[sha256sum] = "5badb0ed25924ee62099efed8ce1a1448e82e28bbfb6fc16496c27f898a565a1"

