# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma-mobile/21.07/kweather-21.07.tar.xz"
SRC_URI[sha256sum] = "5429d7d954abe99a5ec652ff9597ac05294112ef23c9d6a66900ed25b8e84e24"

