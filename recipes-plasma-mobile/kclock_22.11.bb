# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma-mobile/22.11/kclock-22.11.tar.xz"
SRC_URI[sha256sum] = "a48c8eb50af485bb12d872be7674ed56e3887b4619b47438c1e385bddc27660b"

