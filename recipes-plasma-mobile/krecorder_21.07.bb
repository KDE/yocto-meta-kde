# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma-mobile/21.07/krecorder-21.07.tar.xz"
SRC_URI[sha256sum] = "1e50439c3cf247ac4e3e3dbabce3c7ced97f68441755d4c4135f95cca7877ea3"

