# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma-mobile/22.11/kongress-22.11.tar.xz"
SRC_URI[sha256sum] = "aba9b0b2f8060b31e338ef9f4707ed7ee88fbf07cfece2065583f69d26eb280f"

