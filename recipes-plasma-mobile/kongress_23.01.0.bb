# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma-mobile/23.01.0/kongress-23.01.0.tar.xz"
SRC_URI[sha256sum] = "259399ac3214a091dc42ec5fc81e7f520b7973b3abe430b886db4a4dc80aaa7a"

