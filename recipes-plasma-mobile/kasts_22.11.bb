# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma-mobile/22.11/kasts-22.11.tar.xz"
SRC_URI[sha256sum] = "2912b4a8864e35a7dadc16b9368988b6163870a0358e020c3b80b31222002711"

