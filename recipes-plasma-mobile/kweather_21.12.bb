# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma-mobile/21.12/kweather-21.12.tar.xz"
SRC_URI[sha256sum] = "f2e4db4833d4751401075be447261cfc8d5996b55d090144fd79e903678e3b80"

