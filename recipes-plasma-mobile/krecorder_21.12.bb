# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma-mobile/21.12/krecorder-21.12.tar.xz"
SRC_URI[sha256sum] = "9c84d62cd658ca842a04eb49447bc4e0332a8bf3f23dab300306aa24fc45b109"

