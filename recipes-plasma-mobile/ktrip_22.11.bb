# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma-mobile/22.11/ktrip-22.11.tar.xz"
SRC_URI[sha256sum] = "c7eb0b95203204bb54be026fcaa9c7216b5287c77e11cf35ec1108796572b21e"

