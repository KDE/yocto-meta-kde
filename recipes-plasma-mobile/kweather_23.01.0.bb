# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma-mobile/23.01.0/kweather-23.01.0.tar.xz"
SRC_URI[sha256sum] = "fae48fc7aa8fc2c0578c7d942326e021662ff0e9f3280f6ff78c2fd1bf448bc1"

