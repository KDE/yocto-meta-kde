# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma-mobile/21.12/alligator-21.12.tar.xz"
SRC_URI[sha256sum] = "7c5a8d05f241c0ba774b6a8da11c0b04098ca34fd3fa62fd11b6055b56ba8e3c"

