# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma-mobile/22.11/koko-22.11.tar.xz"
SRC_URI[sha256sum] = "7b1dc3a26c9f78c03c0c572e7741b800492ec8896cdb26e36af7faab539312cb"

