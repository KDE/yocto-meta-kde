# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma-mobile/23.01.0/krecorder-23.01.0.tar.xz"
SRC_URI[sha256sum] = "165e5006fdd8af3c0262c6f17fac35ee25a491015aaa17078126dd85111f4a2a"

