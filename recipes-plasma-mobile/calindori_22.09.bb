# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma-mobile/22.09/calindori-22.09.tar.xz"
SRC_URI[sha256sum] = "96505d78e4b040fa397e3e99fd6648f3e163d8f050fe19c184d59c6b3f6e8fdf"

