# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma-mobile/22.09/plasma-settings-22.09.tar.xz"
SRC_URI[sha256sum] = "6a3aaf404c2c9f2fc98b376a4539069ddd4c793056121b4846ea883fd9c9024b"

