# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma-mobile/21.07/alligator-21.07.tar.xz"
SRC_URI[sha256sum] = "53252a6153c8157ab7b8146e70e0a2f11be142481c6306a92073eba578109dfd"

