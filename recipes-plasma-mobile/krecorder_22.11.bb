# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma-mobile/22.11/krecorder-22.11.tar.xz"
SRC_URI[sha256sum] = "8b834257fca41b24aaa860195cbbb25e23f76d4641c224b53e8c03162e8331f2"

