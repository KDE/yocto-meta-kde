# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma-mobile/21.12/calindori-21.12.tar.xz"
SRC_URI[sha256sum] = "2bc72b24d96499afb1418c6de3657a7639a74076a04eb43e3fbc5c08567ba9e6"

