# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma-mobile/23.01.0/ktrip-23.01.0.tar.xz"
SRC_URI[sha256sum] = "1546edebeec36fa313e587cb432817af0136a125f51b2882489532084373c9d0"

