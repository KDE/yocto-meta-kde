# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma-mobile/22.09/kweather-22.09.tar.xz"
SRC_URI[sha256sum] = "5f864f8f9ee8d17dc0647806c9237efd4df82ee31d022e80cf32e4e053317f7c"

