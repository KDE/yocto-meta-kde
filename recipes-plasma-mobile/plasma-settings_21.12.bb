# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma-mobile/21.12/plasma-settings-21.12.tar.xz"
SRC_URI[sha256sum] = "a7d10ebb970ea01c1bbb38680155f9f1727794b37e03f6c7eb3f362dc9e226bf"

