# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma-mobile/22.11/calindori-22.11.tar.xz"
SRC_URI[sha256sum] = "ac2cd82ccfed3ee3970005eb0296413a383db98a4a603539bb4bdafa8369edd5"

