# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma-mobile/22.09/kongress-22.09.tar.xz"
SRC_URI[sha256sum] = "5f0af711e8f603b0d11651243d7c8fd325152a5568454c6713fc69728e16575e"

