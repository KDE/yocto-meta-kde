# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma-mobile/23.01.0/calindori-23.01.0.tar.xz"
SRC_URI[sha256sum] = "14ba0b525893fd51ad04a11a6948556be037ddd5545864f0c540b467a0ee194a"

