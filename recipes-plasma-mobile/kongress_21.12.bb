# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma-mobile/21.12/kongress-21.12.tar.xz"
SRC_URI[sha256sum] = "fcf36d60d7cb947820defb668c63ca5249e48257d78256fca02ce75704be05ad"

