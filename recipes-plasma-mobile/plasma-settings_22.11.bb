# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma-mobile/22.11/plasma-settings-22.11.tar.xz"
SRC_URI[sha256sum] = "b2e01bd415dd20872281f636496d1db617a5b84e5e6dc63b9f9fd8c5e80de75d"

