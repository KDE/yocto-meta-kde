# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma-mobile/22.09/koko-22.09.tar.xz"
SRC_URI[sha256sum] = "f40dcd9bd3ba686435dbf4b3b1a54bdd8a994b3f4875266a9deba9e004d37efc"

