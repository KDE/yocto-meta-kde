# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma-mobile/21.07/kclock-21.07.tar.xz"
SRC_URI[sha256sum] = "c43c2f2b2f8b046e061ef16079c98c8f2b00d5724a2dfef5ca86677e3131222c"

