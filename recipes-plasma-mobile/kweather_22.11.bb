# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma-mobile/22.11/kweather-22.11.tar.xz"
SRC_URI[sha256sum] = "b4d931e87dc9b2a54480de80634cc67d6d4cea03d29aae9e9279c3723d390c6b"

