# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma-mobile/23.01.0/alligator-23.01.0.tar.xz"
SRC_URI[sha256sum] = "6caf6777621c5d3a013e211c19a2b2d488be8591f8796030dc49e2bf1b926c03"

