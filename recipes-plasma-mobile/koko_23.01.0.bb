# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma-mobile/23.01.0/koko-23.01.0.tar.xz"
SRC_URI[sha256sum] = "d792e948799153368eea4843ff1c884719a5da9acab2889c5d43c2bb1577cbad"

