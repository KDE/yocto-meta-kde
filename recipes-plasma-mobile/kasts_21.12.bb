# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma-mobile/21.12/kasts-21.12.tar.xz"
SRC_URI[sha256sum] = "601719980e3b9853f8ca136cd48395874c0ecb4eed36b8ee14376129fb85d5e6"

