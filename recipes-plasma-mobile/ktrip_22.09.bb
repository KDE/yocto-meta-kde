# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma-mobile/22.09/ktrip-22.09.tar.xz"
SRC_URI[sha256sum] = "34d7bb14cb69acbfa8576e57d05004a1739323b22be9365efdc76f2ba0273a75"

