# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma-mobile/22.09/kasts-22.09.tar.xz"
SRC_URI[sha256sum] = "060d523a4e6428a2d4a6422e3c90aed0ff15ff7afc153279e3087ca3202ca8ca"

