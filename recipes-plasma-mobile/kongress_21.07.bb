# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma-mobile/21.07/kongress-21.07.tar.xz"
SRC_URI[sha256sum] = "54e47b6e6fdc1142b0f6fdb599e12d24c4db8df12842f1715f8586357b917248"

