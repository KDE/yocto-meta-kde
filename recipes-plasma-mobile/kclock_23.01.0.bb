# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/plasma-mobile/23.01.0/kclock-23.01.0.tar.xz"
SRC_URI[sha256sum] = "397c0d8f5fd5792cfeaa629af38bff5f9611519608e83fa99018a7889950ad3b"

